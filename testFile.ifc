Properties of the parts of a building model (IFC2X3), part 4 of 4

# IfcPlate: PL9*74 (20)
Name | Bottom elevation | Top elevation | Preliminary mark = Reference | Area per tons (m2) | Length (mm) | NetArea (m2) | GrossArea (m2) | NetVolume (m3) = GrossVolume (m3)
12 x STIFFENER | +5.134 | +5.460 | K61-29 | 32.5 | 326 | 0.0549729 | 0.024124 | 0.000215595

# IfcPlate: PL9*75 (76)
In: Undefined
Description: PL9*75; Material: STEEL/SS400
Tekla Common - Phase: 1; Class: 325
Tekla Quantity - Weight: 0.6 kg; Volume: 0 m3; Gross footprint area: 0 m2; Net surface area: 0 m2; Height: 75 mm; Width: 9 mm; Length: 120 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 75 mm; GrossArea: 0.009 m2; CrossSectionArea: 0.000081 m2
Name | Bottom elevation | Top elevation | Preliminary mark | Area per tons (m2) | Reference | NetArea (m2) | NetVolume (m3) = GrossVolume (m3)
PLATE | +19.290 | +19.365 | K61-186 | 35.1 | K61-186 | 0.0194985 | 0.0000708128
PLATE | +19.290 | +19.367 | K61-186 | 35.1 | K61-186 | 0.0194985 | 0.0000708128
PLATE | +19.397 | +19.473 | K61-186 | 35.1 | K61-186 | 0.0194985 | 0.0000708128
10 x PLATE | +14.370 | +14.445 | K61-186 | 35.1 | K61-186 | 0.0194985 | 0.0000708128
2 x PLATE | +9.870 | +9.945 | K61-186 | 35.1 | K61-186 | 0.0194985 | 0.0000708128
2 x PLATE | +5.470 | +5.545 | K61-186 | 35.1 | K61-186 | 0.0194985 | 0.0000708128
16 x PLATE | +14.370 | +14.445 | K51-163 | 35 | K51-163 | 0.0193545 | 0.0000704078
14 x PLATE | +9.870 | +9.945 | K51-163 | 35 | K51-163 | 0.0193545 | 0.0000704078
14 x PLATE | +5.470 | +5.545 | K51-163 | 35 | K51-163 | 0.0193545 | 0.0000704078
2 x PLATE | +19.503 | +19.580 | P-2219 | 35 | K51-163 | 0.0193545 | 0.0000704078
2 x PLATE | +19.506 | +19.582 | P-2219 | 35 | K51-163 | 0.0193545 | 0.0000704078
2 x PLATE | +19.291 | +19.367 | P-2219 | 35 | K51-163 | 0.0193545 | 0.0000704078
PLATE | +19.290 | +19.365 | P-2219 | 35 | K51-163 | 0.0193545 | 0.0000704078
4 x PLATE | +19.505 | +19.580 | K51-163 | 35 | K51-163 | 0.0193545 | 0.0000704078
4 x PLATE | +19.290 | +19.365 | K51-163 | 35 | K51-163 | 0.0193545 | 0.0000704078

# IfcPlate: PL9*80 (193)
In: Undefined
Description: PL9*80; Material: STEEL/SS400
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Net surface area: 0 m2; Height: 80 mm; Width: 9 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 80 mm; CrossSectionArea: 0.000081 m2
Name | Bottom elevation | Top elevation | Preliminary mark = Reference | Phase | Class | Weight (kg) | Area per tons (m2) | Length (mm) | NetArea (m2) | GrossArea (m2) | NetVolume (m3) = GrossVolume (m3)
GUSSET | +3.080 | +3.160 | F-4 | 37 | 314 | 0.9 | 33.1 | 155 | 0.02903 | 0.0124 | 0.0001116
GUSSET | +14.370 | +14.525 | KG-57 | 1 | 290 | 0.9 | 33.1 | 155 | 0.02903 | 0.0124 | 0.0001116
2 x GUSSET | +17.918 | +17.927 | KG-57 | 1 | 292 | 0.9 | 33.1 | 155 | 0.02903 | 0.0124 | 0.0001116
2 x GUSSET | +14.963 | +14.972 | KG-57 | 1 | 292 | 0.9 | 33.1 | 155 | 0.02903 | 0.0124 | 0.0001116
GUSSET | +18.695 | +18.850 | KG-57 | 1 | 292 | 0.9 | 33.1 | 155 | 0.02903 | 0.0124 | 0.0001116
GUSSET | +18.695 | +18.850 | K52-240 | 1 | 282 | 0.9 | 33.1 | 155 | 0.02903 | 0.0124 | 0.0001116
GUSSET | +18.695 | +18.850 | K52-239 | 1 | 282 | 0.9 | 33.1 | 155 | 0.02903 | 0.0124 | 0.0001116
2 x GUSSET | +15.450 | +15.530 | K2-22 | 1 | 314 | 0.9 | 33.1 | 155 | 0.02903 | 0.0124 | 0.0001116
4 x GUSSET | +18.695 | +18.850 | K52-217 | 1 | 314 | 0.9 | 33.1 | 155 | 0.02903 | 0.0124 | 0.0001116
3 x GUSSET | +14.370 | +14.525 | K52-217 | 1 | 314 | 0.9 | 33.1 | 155 | 0.02903 | 0.0124 | 0.0001116
GUSSET | +18.801 | +18.957 | K52-218 | 1 | 314 | 0.9 | 33.1 | 156.6 | 0.0293234 | 0.0125318 | 0.000112787
GUSSET | +18.910 | +19.065 | K52-217 | 1 | 314 | 0.9 | 33.1 | 155 | 0.02903 | 0.0124 | 0.0001116
GUSSET | +18.801 | +18.957 | K62-288 | 1 | 314 | 0.9 | 33.1 | 156.6 | 0.0293167 | 0.0125288 | 0.00011276
3 x GUSSET | +18.695 | +18.850 | K62-227 | 1 | 314 | 0.9 | 33.1 | 155 | 0.02903 | 0.0124 | 0.0001116
GUSSET | +18.693 | +18.848 | K62-234 | 1 | 314 | 0.9 | 33.1 | 155 | 0.02903 | 0.0124 | 0.0001116
2 x GUSSET | +18.695 | +18.850 | K62-234 | 1 | 314 | 0.9 | 33.1 | 155 | 0.02903 | 0.0124 | 0.0001116
GUSSET | +18.693 | +18.848 | K62-227 | 1 | 314 | 0.9 | 33.1 | 155 | 0.02903 | 0.0124 | 0.0001116
3 x GUSSET | +18.955 | +19.035 | K52-58 | 1 | 314 | 0.6 | 34 | 100 | 0.01924 | 0.008 | 0.000072
3 x GUSSET | +18.973 | +19.053 | K52-58 | 1 | 314 | 0.6 | 34 | 100 | 0.01924 | 0.008 | 0.000072
3 x GUSSET | +18.992 | +19.072 | K52-58 | 1 | 314 | 0.6 | 34 | 100 | 0.01924 | 0.008 | 0.000072
3 x GUSSET | +19.011 | +19.091 | K52-58 | 1 | 314 | 0.6 | 34 | 100 | 0.01924 | 0.008 | 0.000072
3 x GUSSET | +19.030 | +19.110 | K52-58 | 1 | 314 | 0.6 | 34 | 100 | 0.01924 | 0.008 | 0.000072
3 x GUSSET | +19.049 | +19.129 | K52-58 | 1 | 314 | 0.6 | 34 | 100 | 0.01924 | 0.008 | 0.000072
3 x GUSSET | +19.067 | +19.148 | K52-58 | 1 | 314 | 0.6 | 34 | 100 | 0.01924 | 0.008 | 0.000072
3 x GUSSET | +19.086 | +19.166 | K52-58 | 1 | 314 | 0.6 | 34 | 100 | 0.01924 | 0.008 | 0.000072
3 x GUSSET | +19.105 | +19.185 | K52-58 | 1 | 314 | 0.6 | 34 | 100 | 0.01924 | 0.008 | 0.000072
3 x GUSSET | +19.124 | +19.204 | K52-58 | 1 | 314 | 0.6 | 34 | 100 | 0.01924 | 0.008 | 0.000072
3 x GUSSET | +19.143 | +19.223 | K52-58 | 1 | 314 | 0.6 | 34 | 100 | 0.01924 | 0.008 | 0.000072
3 x GUSSET | +19.162 | +19.242 | K52-58 | 1 | 314 | 0.6 | 34 | 100 | 0.01924 | 0.008 | 0.000072
3 x GUSSET | +19.170 | +19.250 | K52-58 | 1 | 314 | 0.6 | 34 | 100 | 0.01924 | 0.008 | 0.000072
3 x GUSSET | +19.189 | +19.269 | K52-58 | 1 | 314 | 0.6 | 34 | 100 | 0.01924 | 0.008 | 0.000072
3 x GUSSET | +19.208 | +19.288 | K52-58 | 1 | 314 | 0.6 | 34 | 100 | 0.01924 | 0.008 | 0.000072
8 x GUSSET | +18.955 | +19.035 | K62-37 | 1 | 314 | 0.6 | 34 | 100 | 0.01924 | 0.008 | 0.000072
8 x GUSSET | +18.973 | +19.053 | K62-37 | 1 | 314 | 0.6 | 34 | 100 | 0.01924 | 0.008 | 0.000072
8 x GUSSET | +18.992 | +19.072 | K62-37 | 1 | 314 | 0.6 | 34 | 100 | 0.01924 | 0.008 | 0.000072
8 x GUSSET | +19.011 | +19.091 | K62-37 | 1 | 314 | 0.6 | 34 | 100 | 0.01924 | 0.008 | 0.000072
8 x GUSSET | +19.030 | +19.110 | K62-37 | 1 | 314 | 0.6 | 34 | 100 | 0.01924 | 0.008 | 0.000072
8 x GUSSET | +19.049 | +19.129 | K62-37 | 1 | 314 | 0.6 | 34 | 100 | 0.01924 | 0.008 | 0.000072
8 x GUSSET | +19.067 | +19.148 | K62-37 | 1 | 314 | 0.6 | 34 | 100 | 0.01924 | 0.008 | 0.000072
8 x GUSSET | +19.086 | +19.166 | K62-37 | 1 | 314 | 0.6 | 34 | 100 | 0.01924 | 0.008 | 0.000072
8 x GUSSET | +19.105 | +19.185 | K62-37 | 1 | 314 | 0.6 | 34 | 100 | 0.01924 | 0.008 | 0.000072
8 x GUSSET | +19.124 | +19.204 | K62-37 | 1 | 314 | 0.6 | 34 | 100 | 0.01924 | 0.008 | 0.000072
8 x GUSSET | +19.143 | +19.223 | K62-37 | 1 | 314 | 0.6 | 34 | 100 | 0.01924 | 0.008 | 0.000072
8 x GUSSET | +19.162 | +19.242 | K62-37 | 1 | 314 | 0.6 | 34 | 100 | 0.01924 | 0.008 | 0.000072
8 x GUSSET | +19.170 | +19.250 | K62-37 | 1 | 314 | 0.6 | 34 | 100 | 0.01924 | 0.008 | 0.000072
8 x GUSSET | +19.189 | +19.269 | K62-37 | 1 | 314 | 0.6 | 34 | 100 | 0.01924 | 0.008 | 0.000072
8 x GUSSET | +19.208 | +19.288 | K62-37 | 1 | 314 | 0.6 | 34 | 100 | 0.01924 | 0.008 | 0.000072

# IfcPlate: PL9*86 (10)
In: Undefined
Description: PL9*86; Material: STEEL/SS400
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Width: 9 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - CrossSectionArea: 0.000081 m2
Name | Bottom elevation | Top elevation | Preliminary mark | Phase | Class | Weight (kg) | Area per tons (m2) | Net surface area (m2) | Height (mm) = Width (mm) | Length (mm) | Reference | NetArea (m2) | GrossArea (m2) | NetVolume (m3) = GrossVolume (m3)
6 x STIFFENER | +19.049 | +19.327 | K62-311 | 1 | 283 | 1.8 | 32.2 | 0.1 | 85.5 | 278 | K62-311 | 0.0536059 | 0.023769 | 0.0002124
STIFFENER | +18.330 | +18.416 |  | 7 | 314 | 1.6 | 32.2 | 0.1 | 86 | 268 | K82-30 | 0.0519929 | 0.023048 | 0.000205911
STIFFENER | +18.861 | +19.035 | K62-241 | 1 | 314 | 0.9 | 33.1 | 0 | 86 | 174 | K62-241 | 0.0305481 | 0.014964 | 0.000117641
STIFFENER | +13.683 | +14.357 | K62-39 | 1 | 314 | 3.9 | 31.6 | 0.1 | 85.5 | 674 | K62-39 | 0.128087 | 0.057627 | 0.000515727
STIFFENER | +4.783 | +5.457 | K61-27 | 1 | 314 | 3.9 | 31.6 | 0.1 | 85.5 | 674 | K61-27 | 0.128087 | 0.057627 | 0.000515727

# IfcPlate: PL9*87 (59)
In: Undefined
Description: PL9*87
Tekla Common - Phase: 1; Class: 314
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Net surface area: 0.1 m2; Height: 87 mm; Width: 9 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - CrossSectionArea: 0.000081 m2
Name | Material | Bottom elevation | Top elevation | Preliminary mark = Reference | Weight (kg) | Area per tons (m2) | Length (mm) | Width (mm) | NetArea (m2) | GrossArea (m2) | NetVolume (m3) | GrossVolume (m3)
7 x GUSSET | STEEL/SN400B | +18.893 | +19.247 | K2-10 | 2.1 | 32.9 | 354 | 87 | 0.0675867 | 0.030798 | 0.000262845 | 0.000277182
8 x GUSSET | STEEL/SN400B | +19.108 | +19.462 | K2-10 | 2.1 | 32.9 | 354 | 87 | 0.0675867 | 0.030798 | 0.000262845 | 0.000277182
2 x GUSSET | STEEL/SN490B | +4.827 | +5.413 | K1-19 | 3.4 | 32.5 | 586 | 86.9997 | 0.110907 | 0.0509818 | 0.000435103 | 0.000458837
2 x GUSSET | STEEL/SN490B | +13.727 | +14.313 | K2-5 | 3.4 | 32.5 | 586 | 86.9997 | 0.110907 | 0.0509818 | 0.000435103 | 0.000458837
5 x GUSSET | STEEL/SN490B | +13.719 | +14.321 | K2-7 | 3.4 | 32.5 | 602 | 87 | 0.113895 | 0.052374 | 0.000446985 | 0.000471366
3 x GUSSET | STEEL/SN490B | +13.719 | +14.321 | K2-7 | 3.4 | 32.5 | 602 | 86.9997 | 0.113895 | 0.0523738 | 0.000446983 | 0.000471366
4 x GUSSET | STEEL/SN490B | +13.723 | +14.325 | K2-7 | 3.4 | 32.5 | 602 | 86.9997 | 0.113895 | 0.0523738 | 0.000446983 | 0.000471366
GUSSET | STEEL/SN490B | +9.227 | +9.813 | K1-19 | 3.4 | 32.5 | 586 | 86.9997 | 0.110907 | 0.0509818 | 0.000435103 | 0.000458837
4 x GUSSET | STEEL/SN490B | +9.219 | +9.821 | K1-18 | 3.4 | 32.5 | 602 | 86.9997 | 0.113895 | 0.0523738 | 0.000446983 | 0.000471366
4 x GUSSET | STEEL/SN490B | +4.819 | +5.421 | K1-18 | 3.4 | 32.5 | 602 | 86.9997 | 0.113895 | 0.0523738 | 0.000446983 | 0.000471366
7 x GUSSET | STEEL/SN490B | +9.219 | +9.821 | K1-18 | 3.4 | 32.5 | 602 | 87 | 0.113895 | 0.052374 | 0.000446985 | 0.000471366
6 x GUSSET | STEEL/SN490B | +4.819 | +5.421 | K1-18 | 3.4 | 32.5 | 602 | 87 | 0.113895 | 0.052374 | 0.000446985 | 0.000471366
2 x GUSSET | STEEL/SN490B | +4.823 | +5.425 | K1-18 | 3.4 | 32.5 | 602 | 86.9997 | 0.113895 | 0.0523738 | 0.000446983 | 0.000471366
2 x GUSSET | STEEL/SN490B | +9.223 | +9.825 | K1-18 | 3.4 | 32.5 | 602 | 86.9997 | 0.113895 | 0.0523738 | 0.000446983 | 0.000471366
GUSSET | STEEL/SN490B | +13.731 | +14.309 | K2-6 | 3.4 | 32.5 | 578 | 87 | 0.109414 | 0.050286 | 0.000429165 | 0.000452572
GUSSET | STEEL/SN490B | +13.727 | +14.313 | K2-5 | 3.4 | 32.5 | 586 | 87 | 0.110908 | 0.050982 | 0.000435105 | 0.000458837

# IfcPlate: PL9*90 (8)
In: Undefined
Description: PL9*90; Material: STEEL/SS400
Tekla Common - Bottom elevation: -0.534; Top elevation: -0.334; Preliminary mark: F-5; Phase: 37; Class: 314
Tekla Quantity - Weight: 0.9 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 33.5 m2; Net surface area: 0 m2; Height: 90 mm; Width: 9 mm; Length: 200 mm
Pset_PlateCommon - LoadBearing: no; Reference: F-5
BaseQuantities - Width: 90 mm; NetArea: 0.0304198 m2; GrossArea: 0.018 m2; CrossSectionArea: 0.000081 m2; NetVolume: 0.00011565 m3; GrossVolume: 0.00011565 m3

# IfcPlate: PL9*92 (31)
In: Undefined
Description: PL9*92; Material: STEEL/SS400
Tekla Common - Preliminary mark: K12-1; Phase: 1; Class: 314
Tekla Quantity - Weight: 1.6 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 33.4 m2; Net surface area: 0.1 m2; Height: 92 mm; Width: 9 mm; Length: 278 mm
Pset_PlateCommon - LoadBearing: no; Reference: K12-1
BaseQuantities - Width: 92 mm; NetArea: 0.0533398 m2; GrossArea: 0.025576 m2; CrossSectionArea: 0.000081 m2; NetVolume: 0.000203378 m3; GrossVolume: 0.000203378 m3
Name | Bottom elevation | Top elevation
3 x GUSSET | +19.480 | +19.494
3 x GUSSET | +19.446 | +19.459
3 x GUSSET | +19.275 | +19.289
3 x GUSSET | +19.324 | +19.339
3 x GUSSET | +19.333 | +19.348
3 x GUSSET | +19.437 | +19.452
2 x GUSSET | +19.390 | +19.404
2 x GUSSET | +19.381 | +19.395
3 x GUSSET | +19.550 | +19.564
3 x GUSSET | +19.540 | +19.555
3 x GUSSET | +19.490 | +19.504

# IfcPlate: PL9*97 (3)
In: Undefined
Description: PL9*97; Material: STEEL/SN490B
Tekla Common - Phase: 1; Class: 314
Tekla Quantity - Weight: 1.2 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 32.9 m2; Net surface area: 0 m2; Height: 97 mm; Width: 9 mm; Length: 200 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - CrossSectionArea: 0.000081 m2; GrossVolume: 0.000174599 m3
Name | Bottom elevation | Top elevation | Preliminary mark = Reference | Width (mm) | NetArea (m2) | GrossArea (m2) | NetVolume (m3)
GUSSET | +0.044 | +0.258 | K1-15 | 96.9997 | 0.0430105 | 0.0193999 | 0.000166499
GUSSET | +4.175 | +4.356 | K51-3 | 96.9972 | 0.0430094 | 0.0193994 | 0.000166495
GUSSET | +0.427 | +0.607 | K1-15 | 96.9997 | 0.0430105 | 0.0193999 | 0.000166499

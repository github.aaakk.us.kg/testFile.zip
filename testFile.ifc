Properties of the parts of a building model (IFC2X3), part 1 of 4

# File
Description: ViewDefinition[CoordinationView_V2.0, QuantityTakeOffAddOnView], Option [BaseQuantities:On], Option [GridExport:On], Option [Assemblies:Off], Option [Bolts:On], Option [Rebars:On], Option [PourObjects:Off], Option [Welds:Off], Option [SurfaceTreatments:On], Option [LocationBy:0], Option [ViewColors:Off], Option [SectionedSpine:Off], Option [PropertySets:On], Option [Export all:Off]
File name: Teklaモデル.ifc
Time: 2024-04-12T15:33:45
Author: TAKENAKA\B012364
Organization: Structural Designer
Written by: IFC Parser Version: 3.13.2
Made in: IFC Export Version: 4

# IfcBuildingStorey, Undefined
In: Undefined
Elevation: 0 mm

# IfcBeam: C-100X50X20X2.3 (260)
In: Undefined
Description: C-100X50X20X2.3
Tekla Quantity - Volume: 0 m3; Area per tons: 112 m2; Height: 100 mm; Width: 50 mm
Pset_BeamCommon - LoadBearing: no
Name | Material | Bottom elevation | Top elevation | Preliminary mark | Phase | Class | Weight (kg) | Gross footprint area (m2) | Net surface area (m2) | Tekla Quantity, Length (mm) | Reference | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
C100 | STEEL/SS400 | +19.290 | +19.340 | KC-7 | 1 | 63 | 11.7 | 0.4 | 1.3 | 2880 | KC-24 | 2880 | 1.30959 | 0.00152882 | 12.0012
C100 | STEEL/SS400 | +19.290 | +19.340 | KC-20 | 1 | 63 | 6.1 | 0.2 | 0.7 | 1517.5 | KC-20 | 1517.5 | 0.690038 | 0.00080555 | 6.32357
C100 | STEEL/SS400 | +19.290 | +19.340 | KC-19 | 1 | 63 | 15.6 | 0.4 | 1.8 | 3850 | KC-19 | 3850 | 1.75067 | 0.00204373 | 16.0433
C100 | STEEL/SS400 | +19.290 | +19.340 | KC-13 | 1 | 63 | 4.8 | 0.1 | 0.4 | 1170 | KC-13 | 1170 | 0.532022 | 0.000621083 | 4.8755
C100 | STEEL/SS400 | +19.290 | +19.340 | KC-18 | 1 | 63 | 5.2 | 0.1 | 0.7 | 1270 | KC-18 | 1270 | 0.577495 | 0.000674167 | 5.29221
C100 | STEEL/SS400 | +19.505 | +19.555 | KC-18 | 1 | 63 | 5.2 | 0.1 | 0.7 | 1270 | KC-18 | 1270 | 0.577495 | 0.000674167 | 5.29221
2 x C100 | STEEL/SS400 | +19.505 | +19.555 | KC-15 | 1 | 63 | 48.2 | 1.2 | 5.5 | 11860 | KC-15 | 11860 | 5.39298 | 0.00629576 | 49.4217
C100 | STEEL/SS400 | +19.290 | +19.340 | KC-15 | 1 | 63 | 48.2 | 1.2 | 5.5 | 11860 | KC-15 | 11860 | 5.39298 | 0.00629576 | 49.4217
C100 | STEEL/SS400 | +19.340 | +19.392 | KC-11 | 1 | 63 | 3.9 | 0 | 0.4 | 970 | KC-11 | 970.005 | 0.441081 | 0.000514917 | 4.0421
C100 | STEEL/SS400 | +19.397 | +19.449 | KC-11 | 1 | 63 | 3.9 | 0 | 0.4 | 970 | KC-11 | 970.005 | 0.441081 | 0.000514917 | 4.0421
C100 | STEEL/SS400 | +19.453 | +19.505 | KC-11 | 1 | 63 | 3.9 | 0 | 0.4 | 970 | KC-11 | 970.005 | 0.441081 | 0.000514917 | 4.0421
C100 | STEEL/SS400 | +19.556 | +19.608 | KC-11 | 1 | 63 | 3.9 | 0 | 0.4 | 970 | KC-11 | 970.005 | 0.441081 | 0.000514917 | 4.0421
3 x C100 | STEEL/SS400 | +19.340 | +19.392 | KC-5 | 1 | 63 | 10.9 | 0 | 1.3 | 2680.5 | KC-5 | 2680.5 | 1.21888 | 0.00142292 | 11.1699
3 x C100 | STEEL/SS400 | +19.397 | +19.449 | KC-5 | 1 | 63 | 10.9 | 0 | 1.3 | 2680.5 | KC-5 | 2680.5 | 1.21888 | 0.00142292 | 11.1699
3 x C100 | STEEL/SS400 | +19.453 | +19.505 | KC-5 | 1 | 63 | 10.9 | 0 | 1.3 | 2680.5 | KC-5 | 2680.5 | 1.21888 | 0.00142292 | 11.1699
3 x C100 | STEEL/SS400 | +19.556 | +19.608 | KC-5 | 1 | 63 | 10.9 | 0 | 1.3 | 2680.5 | KC-5 | 2680.5 | 1.21888 | 0.00142292 | 11.1699
3 x C100 | STEEL/SS400 | +19.340 | +19.392 | KC-8 | 1 | 63 | 11.1 | 0 | 1.3 | 2731 | KC-8 | 2731 | 1.24184 | 0.00144972 | 11.3803
3 x C100 | STEEL/SS400 | +19.397 | +19.449 | KC-8 | 1 | 63 | 11.1 | 0 | 1.3 | 2731 | KC-8 | 2731 | 1.24184 | 0.00144972 | 11.3803
3 x C100 | STEEL/SS400 | +19.453 | +19.505 | KC-8 | 1 | 63 | 11.1 | 0 | 1.3 | 2731 | KC-8 | 2731 | 1.24184 | 0.00144972 | 11.3803
3 x C100 | STEEL/SS400 | +19.556 | +19.608 | KC-8 | 1 | 63 | 11.1 | 0 | 1.3 | 2731 | KC-8 | 2731 | 1.24184 | 0.00144972 | 11.3803
3 x RT1 | STEEL/SSC400 | +19.150 | +19.251 | TC-2 | 36 | 50 | 12.7 | 0 | 1.4 | 3121.5 | TC-2 | 3121.5 | 1.41941 | 0.00165702 | 13.0076
3 x RT1 | STEEL/SSC400 | +19.132 | +19.233 | TC-2 | 36 | 50 | 12.7 | 0 | 1.4 | 3121.5 | TC-2 | 3121.5 | 1.41941 | 0.00165702 | 13.0076
3 x RT1 | STEEL/SSC400 | +19.113 | +19.214 | TC-2 | 36 | 50 | 12.7 | 0 | 1.4 | 3121.5 | TC-2 | 3121.5 | 1.41941 | 0.00165702 | 13.0076
3 x RT1 | STEEL/SSC400 | +19.094 | +19.195 | TC-2 | 36 | 50 | 12.7 | 0 | 1.4 | 3121.5 | TC-2 | 3121.5 | 1.41941 | 0.00165702 | 13.0076
3 x RT1 | STEEL/SSC400 | +19.075 | +19.176 | TC-2 | 36 | 50 | 12.7 | 0 | 1.4 | 3121.5 | TC-2 | 3121.5 | 1.41941 | 0.00165702 | 13.0076
3 x RT1 | STEEL/SSC400 | +19.056 | +19.157 | TC-2 | 36 | 50 | 12.7 | 0 | 1.4 | 3121.5 | TC-2 | 3121.5 | 1.41941 | 0.00165702 | 13.0076
3 x RT1 | STEEL/SSC400 | +19.038 | +19.139 | TC-2 | 36 | 50 | 12.7 | 0 | 1.4 | 3121.5 | TC-2 | 3121.5 | 1.41941 | 0.00165702 | 13.0076
3 x RT1 | STEEL/SSC400 | +19.158 | +19.260 | TC-2 | 36 | 50 | 12.7 | 0 | 1.4 | 3121.5 | TC-2 | 3121.5 | 1.41941 | 0.00165702 | 13.0076
3 x RT1 | STEEL/SSC400 | +19.178 | +19.279 | TC-2 | 36 | 50 | 12.7 | 0 | 1.4 | 3121.5 | TC-2 | 3121.5 | 1.41941 | 0.00165702 | 13.0076
3 x RT1 | STEEL/SSC400 | +19.197 | +19.298 | TC-2 | 36 | 50 | 12.7 | 0 | 1.4 | 3121.5 | TC-2 | 3121.5 | 1.41941 | 0.00165702 | 13.0076
3 x RT1 | STEEL/SSC400 | +19.216 | +19.317 | TC-2 | 36 | 50 | 12.7 | 0 | 1.4 | 3121.5 | TC-2 | 3121.5 | 1.41941 | 0.00165702 | 13.0076
3 x RT1 | STEEL/SSC400 | +19.019 | +19.120 | TC-2 | 36 | 50 | 12.7 | 0 | 1.4 | 3121.5 | TC-2 | 3121.5 | 1.41941 | 0.00165702 | 13.0076
3 x RT1 | STEEL/SSC400 | +19.000 | +19.101 | TC-2 | 36 | 50 | 12.7 | 0 | 1.4 | 3121.5 | TC-2 | 3121.5 | 1.41941 | 0.00165702 | 13.0076
3 x RT1 | STEEL/SSC400 | +18.981 | +19.082 | TC-2 | 36 | 50 | 12.7 | 0 | 1.4 | 3121.5 | TC-2 | 3121.5 | 1.41941 | 0.00165702 | 13.0076
3 x RT1 | STEEL/SSC400 | +18.962 | +19.063 | TC-2 | 36 | 50 | 12.7 | 0 | 1.4 | 3121.5 | TC-2 | 3121.5 | 1.41941 | 0.00165702 | 13.0076
3 x RT1 | STEEL/SSC400 | +18.943 | +19.044 | TC-2 | 36 | 50 | 12.7 | 0 | 1.4 | 3121.5 | TC-2 | 3121.5 | 1.41941 | 0.00165702 | 13.0076
3 x RT1 | STEEL/SSC400 | +18.943 | +19.044 | TC-3 | 36 | 50 | 12.7 | 0 | 1.4 | 3124 | TC-3 | 3124 | 1.42055 | 0.00165834 | 13.018
3 x RT1 | STEEL/SSC400 | +18.962 | +19.063 | TC-3 | 36 | 50 | 12.7 | 0 | 1.4 | 3124 | TC-3 | 3124 | 1.42055 | 0.00165834 | 13.018
3 x RT1 | STEEL/SSC400 | +18.981 | +19.082 | TC-3 | 36 | 50 | 12.7 | 0 | 1.4 | 3124 | TC-3 | 3124 | 1.42055 | 0.00165834 | 13.018
3 x RT1 | STEEL/SSC400 | +19.000 | +19.101 | TC-3 | 36 | 50 | 12.7 | 0 | 1.4 | 3124 | TC-3 | 3124 | 1.42055 | 0.00165834 | 13.018
3 x RT1 | STEEL/SSC400 | +19.019 | +19.120 | TC-3 | 36 | 50 | 12.7 | 0 | 1.4 | 3124 | TC-3 | 3124 | 1.42055 | 0.00165834 | 13.018
3 x RT1 | STEEL/SSC400 | +19.216 | +19.317 | TC-3 | 36 | 50 | 12.7 | 0 | 1.4 | 3124 | TC-3 | 3124 | 1.42055 | 0.00165834 | 13.018
3 x RT1 | STEEL/SSC400 | +19.197 | +19.298 | TC-3 | 36 | 50 | 12.7 | 0 | 1.4 | 3124 | TC-3 | 3124 | 1.42055 | 0.00165834 | 13.018
3 x RT1 | STEEL/SSC400 | +19.178 | +19.279 | TC-3 | 36 | 50 | 12.7 | 0 | 1.4 | 3124 | TC-3 | 3124 | 1.42055 | 0.00165834 | 13.018
3 x RT1 | STEEL/SSC400 | +19.158 | +19.260 | TC-3 | 36 | 50 | 12.7 | 0 | 1.4 | 3124 | TC-3 | 3124 | 1.42055 | 0.00165834 | 13.018
3 x RT1 | STEEL/SSC400 | +19.038 | +19.139 | TC-3 | 36 | 50 | 12.7 | 0 | 1.4 | 3124 | TC-3 | 3124 | 1.42055 | 0.00165834 | 13.018
3 x RT1 | STEEL/SSC400 | +19.056 | +19.157 | TC-3 | 36 | 50 | 12.7 | 0 | 1.4 | 3124 | TC-3 | 3124 | 1.42055 | 0.00165834 | 13.018
3 x RT1 | STEEL/SSC400 | +19.075 | +19.176 | TC-3 | 36 | 50 | 12.7 | 0 | 1.4 | 3124 | TC-3 | 3124 | 1.42055 | 0.00165834 | 13.018
3 x RT1 | STEEL/SSC400 | +19.094 | +19.195 | TC-3 | 36 | 50 | 12.7 | 0 | 1.4 | 3124 | TC-3 | 3124 | 1.42055 | 0.00165834 | 13.018
3 x RT1 | STEEL/SSC400 | +19.113 | +19.214 | TC-3 | 36 | 50 | 12.7 | 0 | 1.4 | 3124 | TC-3 | 3124 | 1.42055 | 0.00165834 | 13.018
3 x RT1 | STEEL/SSC400 | +19.132 | +19.233 | TC-3 | 36 | 50 | 12.7 | 0 | 1.4 | 3124 | TC-3 | 3124 | 1.42055 | 0.00165834 | 13.018
3 x RT1 | STEEL/SSC400 | +19.150 | +19.251 | TC-3 | 36 | 50 | 12.7 | 0 | 1.4 | 3124 | TC-3 | 3124 | 1.42055 | 0.00165834 | 13.018
17 x STC | STEEL/SS400 | +18.800 | +18.850 | ST-3 | 1 | 30 | 1.2 | 0 | 0.1 | 300 | ST-3 | 300 | 0.136416 | 0.000159252 | 1.25013
STC | STEEL/SS400 | +19.056 | +19.108 | ST-3 | 1 | 30 | 1.2 | 0 | 0.1 | 300 | ST-3 | 300 | 0.136416 | 0.000159252 | 1.25013
STC | STEEL/SS400 | +19.043 | +19.095 | ST-3 | 1 | 30 | 1.2 | 0 | 0.1 | 300 | ST-3 | 300 | 0.136416 | 0.000159252 | 1.25013
STC | STEEL/SS400 | +19.030 | +19.082 | ST-3 | 1 | 30 | 1.2 | 0 | 0.1 | 300 | ST-3 | 300 | 0.136416 | 0.000159252 | 1.25013
STC | STEEL/SS400 | +19.063 | +19.115 | ST-3 | 1 | 30 | 1.2 | 0 | 0.1 | 300 | ST-3 | 300 | 0.136416 | 0.000159252 | 1.25013
STC | STEEL/SS400 | +19.017 | +19.069 | ST-3 | 1 | 30 | 1.2 | 0 | 0.1 | 300 | ST-3 | 300 | 0.136416 | 0.000159252 | 1.25013
STC | STEEL/SS400 | +19.003 | +19.055 | ST-3 | 1 | 30 | 1.2 | 0 | 0.1 | 300 | ST-3 | 300 | 0.136416 | 0.000159252 | 1.25013
STC | STEEL/SS400 | +18.991 | +19.043 | ST-3 | 1 | 30 | 1.2 | 0 | 0.1 | 300 | ST-3 | 300 | 0.136416 | 0.000159252 | 1.25013
STC | STEEL/SS400 | +18.978 | +19.030 | ST-3 | 1 | 30 | 1.2 | 0 | 0.1 | 300 | ST-3 | 300 | 0.136416 | 0.000159252 | 1.25013
STC | STEEL/SS400 | +18.965 | +19.017 | ST-3 | 1 | 30 | 1.2 | 0 | 0.1 | 300 | ST-3 | 300 | 0.136416 | 0.000159252 | 1.25013
STC | STEEL/SS400 | +18.953 | +19.005 | ST-3 | 1 | 30 | 1.2 | 0 | 0.1 | 300 | ST-3 | 300 | 0.136416 | 0.000159252 | 1.25013
STC | STEEL/SS400 | +18.940 | +18.992 | ST-3 | 1 | 30 | 1.2 | 0 | 0.1 | 300 | ST-3 | 300 | 0.136416 | 0.000159252 | 1.25013
STC | STEEL/SS400 | +18.928 | +18.980 | ST-3 | 1 | 30 | 1.2 | 0 | 0.1 | 300 | ST-3 | 300 | 0.136416 | 0.000159252 | 1.25013
STC | STEEL/SS400 | +18.915 | +18.967 | ST-3 | 1 | 30 | 1.2 | 0 | 0.1 | 300 | ST-3 | 300 | 0.136416 | 0.000159252 | 1.25013
STC | STEEL/SS400 | +18.903 | +18.955 | ST-3 | 1 | 30 | 1.2 | 0 | 0.1 | 300 | ST-3 | 300 | 0.136416 | 0.000159252 | 1.25013
STC | STEEL/SS400 | +18.890 | +18.942 | ST-3 | 1 | 30 | 1.2 | 0 | 0.1 | 300 | ST-3 | 300 | 0.136416 | 0.000159252 | 1.25013
STC | STEEL/SS400 | +18.878 | +18.930 | ST-3 | 1 | 30 | 1.2 | 0 | 0.1 | 300 | ST-3 | 300 | 0.136416 | 0.000159252 | 1.25013
STC | STEEL/SS400 | +18.865 | +18.917 | ST-3 | 1 | 30 | 1.2 | 0 | 0.1 | 300 | ST-3 | 300 | 0.136416 | 0.000159252 | 1.25013
STC | STEEL/SS400 | +18.853 | +18.905 | ST-3 | 1 | 30 | 1.2 | 0 | 0.1 | 300 | ST-3 | 300 | 0.136416 | 0.000159252 | 1.25013
STC | STEEL/SS400 | +18.840 | +18.892 | ST-3 | 1 | 30 | 1.2 | 0 | 0.1 | 300 | ST-3 | 300 | 0.136416 | 0.000159252 | 1.25013
STC | STEEL/SS400 | +18.827 | +18.879 | ST-3 | 1 | 30 | 1.2 | 0 | 0.1 | 300 | ST-3 | 300 | 0.136416 | 0.000159252 | 1.25013
STC | STEEL/SS400 | +18.815 | +18.867 | ST-3 | 1 | 30 | 1.2 | 0 | 0.1 | 300 | ST-3 | 300 | 0.136416 | 0.000159252 | 1.25013
STC | STEEL/SS400 | +19.010 | +19.062 | ST-3 | 1 | 30 | 1.2 | 0 | 0.1 | 300 | ST-3 | 300 | 0.136416 | 0.000159252 | 1.25013
STC | STEEL/SS400 | +18.802 | +18.854 | ST-3 | 1 | 30 | 1.2 | 0 | 0.1 | 300 | ST-3 | 300 | 0.136416 | 0.000159252 | 1.25013
20 x STC | STEEL/SS400 | +13.620 | +13.670 | ST-3 | 1 | 30 | 1.2 | 0 | 0.1 | 300 | ST-3 | 300 | 0.136416 | 0.000159252 | 1.25013
4 x STC | STEEL/SS400 | +9.120 | +9.170 | ST-4 | 1 | 30 | 0.9 | 0 | 0.1 | 200 | ST-4 | 200 | 0.090944 | 0.000106168 | 0.833419
35 x STC | STEEL/SS400 | +9.120 | +9.170 | ST-3 | 1 | 30 | 1.2 | 0 | 0.1 | 300 | ST-3 | 300 | 0.136416 | 0.000159252 | 1.25013
19 x STC | STEEL/SS400 | +4.720 | +4.770 | ST-3 | 1 | 30 | 1.2 | 0 | 0.1 | 300 | ST-3 | 300 | 0.136416 | 0.000159252 | 1.25013
9 x STC | STEEL/SS400 | +4.720 | +4.770 | ST-4 | 1 | 30 | 0.9 | 0 | 0.1 | 200 | ST-4 | 200 | 0.090944 | 0.000106168 | 0.833419

# IfcBeam: C-125X50X20X3.2 (16)
In: Undefined
Description: C-125X50X20X3.2; Material: STEEL/SSC400
Tekla Common - Preliminary mark: NC-1; Phase: 36; Class: 53
Tekla Quantity - Weight: 8.9 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 80.7 m2; Net surface area: 0.7 m2; Height: 125 mm; Width: 50 mm; Length: 1459 mm
Pset_BeamCommon - LoadBearing: no; Reference: NC-1
BaseQuantities - Length: 1459.01 mm; OuterSurfaceArea: 0.721757 m2; NetVolume: 0.00117748 m3; NetWeight: 9.24318 kg
Name | Bottom elevation | Top elevation
RT2 | +19.098 | +19.225
RT2 | +19.080 | +19.206
RT2 | +19.061 | +19.187
RT2 | +19.042 | +19.168
RT2 | +19.023 | +19.149
RT2 | +19.004 | +19.130
RT2 | +18.986 | +19.112
RT2 | +19.107 | +19.233
RT2 | +19.126 | +19.252
RT2 | +19.145 | +19.271
RT2 | +19.164 | +19.290
RT2 | +18.967 | +19.093
RT2 | +18.948 | +19.074
RT2 | +18.929 | +19.055
RT2 | +18.910 | +19.036
RT2 | +18.891 | +19.017

# IfcBeam: CT-150X150X6.5X9 (8)
In: Undefined
Description: CT-150X150X6.5X9; Material: STEEL/SS400
Tekla Common - Finish: a; Bottom elevation: +14.220; Top elevation: +14.370; Phase: 1; Class: 5
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0.4 m2; Area per tons: 32.1 m2; Net surface area: 1.8 m2; Height: 150 mm; Width: 150 mm
Pset_BeamCommon - LoadBearing: no
Name | Preliminary mark = Reference | Weight (kg) | Tekla Quantity, Length (mm) | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
5 x b0 | P-1993 | 53.8 | 2930 | 2930 | 1.7253 | 0.00664085 | 52.1306
2 x b0 | P-1992 | 52.9 | 2880 | 2880.01 | 1.69586 | 0.00652753 | 51.2411
b0 | P-1992 | 52.9 | 2880 | 2879.99 | 1.69586 | 0.00652751 | 51.2409

# IfcBeam: H-100X100X6X8 (24)
In: Undefined
Description: H-100X100X6X8; Material: STEEL/SS400
Tekla Common - Phase: 1; Class: 5
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 33.8 m2; Net surface area: 1.8 m2; Height: 100 mm; Width: 100 mm
Pset_BeamCommon - LoadBearing: no
Name | Finish | Bottom elevation | Top elevation | Preliminary mark = Reference | Weight (kg) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
2 x b10W | a | +19.240 | +19.342 | P-1947 | 48.8 | 2880.5 | 1.65417 | 0.0059252 | 46.5129
3 x b10W | a | +19.240 | +19.342 | P-1948 | 49.7 | 2931 | 1.68317 | 0.00603146 | 47.347
3 x b10W | a | +19.296 | +19.399 | P-1948 | 49.7 | 2931 | 1.68317 | 0.00603146 | 47.347
2 x b10Wc | a | +19.296 | +19.399 | P-1942 | 48.8 | 2880.5 | 1.65417 | 0.0059252 | 46.5129
2 x b10W | a | +19.353 | +19.455 | P-1947 | 48.8 | 2880.5 | 1.65417 | 0.0059252 | 46.5129
3 x b10W | a | +19.353 | +19.455 | P-1948 | 49.7 | 2931 | 1.68317 | 0.00603146 | 47.347
b10W | a | +19.353 | +19.455 | P-1947 | 48.8 | 2880.5 | 1.65417 | 0.00592522 | 46.513
b10Wa | a | +19.296 | +19.399 | P-1942 | 48.8 | 2880.5 | 1.65417 | 0.00592522 | 46.513
b10W | a | +19.240 | +19.342 | P-1947 | 48.8 | 2880.5 | 1.65417 | 0.00592522 | 46.513
b10W |  | +19.456 | +19.558 | P-731 | 49.7 | 2931 | 1.68317 | 0.00603146 | 47.347
2 x b10W | a | +19.456 | +19.558 | P-1948 | 49.7 | 2931 | 1.68317 | 0.00603146 | 47.347
b10W | a | +19.456 | +19.558 | P-1947 | 48.8 | 2880.5 | 1.65417 | 0.0059252 | 46.5129
b10W |  | +19.456 | +19.558 | P-68 | 48.8 | 2880.5 | 1.65417 | 0.00592522 | 46.513
b10W |  | +19.456 | +19.558 | P-68 | 48.8 | 2880.5 | 1.65417 | 0.0059252 | 46.5129

# IfcBeam: H-125X125X6.5X9 (2)
In: Undefined
Description: H-125X125X6.5X9; Material: STEEL/SS400
Tekla Common - Bottom elevation: +3.070; Top elevation: +3.195; Preliminary mark: P-2793; Phase: 37; Class: 25
Tekla Quantity - Weight: 147.3 kg; Volume: 0 m3; Gross footprint area: 0.8 m2; Area per tons: 30.7 m2; Net surface area: 4.6 m2; Height: 125 mm; Width: 125 mm; Length: 6255 mm
Pset_BeamCommon - LoadBearing: no; Reference: P-2793
BaseQuantities - Length: 6255 mm; OuterSurfaceArea: 4.52402 m2; NetVolume: 0.0184241 m3; NetWeight: 144.629 kg

# IfcBeam: H-148X100X6X9 (18)
In: Undefined
Description: H-148X100X6X9; Material: STEEL/SS400
Tekla Quantity - Volume: 0 m3; Area per tons: 32.4 m2; Height: 148 mm; Width: 100 mm
Pset_BeamCommon - LoadBearing: no
Name | Bottom elevation | Top elevation | Preliminary mark = Reference | Phase | Class | Weight (kg) | Gross footprint area (m2) | Net surface area (m2) | Tekla Quantity, Length (mm) | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
cb14M | +15.656 | +15.804 | P-2735 | 1 | 291 | 8.6 | 0 | 0.4 | 415.1 | 415.097 | 0.278225 | 0.00104874 | 8.23259
Hb14M | +14.990 | +15.090 | P-2472 | 7 | 281 | 64.4 | 0.1 | 2.1 | 3115.5 | 3115.5 | 2.08821 | 0.00803799 | 63.0982
cb14M | +15.656 | +15.804 | P-2334 | 1 | 281 | 11.9 | 0.1 | 0.4 | 575.1 | 575.097 | 0.385467 | 0.00146154 | 11.4731
Hb14M | +16.850 | +16.950 | P-2517 | 7 | 27 | 62.7 | 0.1 | 2.1 | 3030 | 3030 | 2.0309 | 0.0078174 | 61.3666
Hb14M | +14.990 | +15.090 | P-2472 | 7 | 27 | 64.4 | 0.1 | 2.1 | 3115.5 | 3115.5 | 2.08821 | 0.00803799 | 63.0983
Hb14M | +16.850 | +16.950 | P-2335 | 7 | 27 | 62.7 | 0.1 | 2.1 | 3030 | 3030 | 2.0309 | 0.0078174 | 61.3666
Hb14M | +14.990 | +15.090 | P-2471 | 7 | 27 | 129.6 | 0.1 | 4.3 | 6265.5 | 6265.49 | 4.19954 | 0.016165 | 126.895
Hb14M | +16.850 | +16.950 | P-2291 | 7 | 27 | 127.8 | 0.1 | 4.3 | 6180 | 6180 | 4.14224 | 0.0159444 | 125.164
3 x cb14M | +15.656 | +15.804 | P-2334 | 1 | 5 | 11.9 | 0.1 | 0.4 | 575.1 | 575.097 | 0.385467 | 0.00146154 | 11.4731
Hb14M | +14.990 | +15.090 | P-2471 | 7 | 27 | 129.6 | 0.1 | 4.3 | 6265.5 | 6265.5 | 4.19955 | 0.016165 | 126.895
Hb14M | +16.850 | +16.950 | P-2291 | 7 | 27 | 127.8 | 0.1 | 4.3 | 6180 | 6180 | 4.14223 | 0.0159444 | 125.163
Hb14M | +18.320 | +18.420 | P-1537 | 7 | 27 | 65.4 | 0.1 | 2.2 | 3163.9 | 3163.89 | 2.12065 | 0.00816285 | 64.0784
2 x Hb14M | +18.320 | +18.420 | P-1535 | 7 | 27 | 108.2 | 0.1 | 3.6 | 5230 | 5230 | 3.50549 | 0.0134934 | 105.923
Hb14M | +18.320 | +18.420 | P-2190 | 7 | 27 | 108.2 | 0.1 | 3.6 | 5230 | 5230 | 3.50549 | 0.0134934 | 105.923
Hb14M | +16.850 | +16.950 | P-1534 | 7 | 27 | 27.8 | 0 | 0.9 | 1345 | 1345 | 0.901509 | 0.00347011 | 27.2404

# IfcBeam: H-150X150X7X10 (9)
In: Undefined
Description: H-150X150X7X10; Material: STEEL/SS400
Tekla Quantity - Volume: 0 m3; Area per tons: 28 m2; Height: 150 mm; Width: 150 mm
Pset_BeamCommon - LoadBearing: no
Name | Bottom elevation | Top elevation | Preliminary mark = Reference | Phase | Class | Weight (kg) | Gross footprint area (m2) | Net surface area (m2) | Tekla Quantity, Length (mm) | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
b15W | +15.654 | +15.804 | P-2732 | 1 | 291 | 92.8 | 0.4 | 2.6 | 2980 | 2980 | 2.59935 | 0.0116518 | 91.4666
b15W | +14.900 | +15.050 | P-2727 | 1 | 294 | 65.2 | 0 | 1.9 | 2094.9 | 2094.9 | 1.82731 | 0.00819107 | 64.2999
b15W | +17.855 | +18.005 | P-2727 | 1 | 294 | 65.2 | 0 | 1.9 | 2094.9 | 2094.9 | 1.82731 | 0.00819107 | 64.2999
b15W | +15.655 | +15.805 | P-2556 | 7 | 27 | 112.1 | 0.4 | 3.2 | 3600 | 3600 | 3.14015 | 0.014076 | 110.497
b15W | +15.655 | +15.805 | P-2555 | 7 | 27 | 192.4 | 0.8 | 5.5 | 6180 | 6180 | 5.3906 | 0.0241638 | 189.686
b15W | +15.487 | +15.637 | P-1495 | 7 | 5 | 84.7 | 0.4 | 2.4 | 2720 | 2720 | 2.37256 | 0.0106352 | 83.4863
2 x b15W | +14.220 | +14.370 | P-1055 | 1 | 5 | 48.5 | 0.2 | 1.3 | 1558 | 1558 | 1.35899 | 0.00587728 | 46.1366
b15W | +19.409 | +19.614 | P-557 | 1 | 5 | 80.3 | 0 | 2.3 | 2580.6 | 2580.62 | 2.25098 | 0.0100902 | 79.2082

# IfcBeam: H-194X150X6X9 (10)
In: Undefined
Description: H-194X150X6X9; Material: STEEL/SS400
Tekla Quantity - Volume: 0 m3; Area per tons: 32.2 m2; Height: 194 mm; Width: 150 mm
Pset_BeamCommon - LoadBearing: no
Name | Bottom elevation | Top elevation | Preliminary mark = Reference | Phase | Class | Weight (kg) | Gross footprint area (m2) | Net surface area (m2) | Tekla Quantity, Length (mm) | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
b19M | +16.803 | +16.997 | P-2705 | 7 | 281 | 89.2 | 0.4 | 2.9 | 2980 | 2980 | 2.86755 | 0.0111929 | 87.8642 | Tekla Common - Finish: b
b19M | +16.803 | +16.997 | P-2553 | 7 | 5 | 89.2 | 0.4 | 2.9 | 2980 | 2980 | 2.86755 | 0.0111929 | 87.8642 | Tekla Common - Finish: a
b19M | +16.803 | +16.997 | P-2550 | 7 | 5 | 183.4 | 0.8 | 6 | 6130 | 6130 | 5.89868 | 0.0230243 | 180.741
b19M | +16.803 | +16.997 | P-2550 | 7 | 5 | 183.4 | 0.8 | 6 | 6130 | 6130.01 | 5.89869 | 0.0230243 | 180.741
2 x b19M | +18.854 | +19.048 | P-195 | 1 | 5 | 89.2 | 0.4 | 2.9 | 2980.5 | 2980.5 | 2.86803 | 0.0111948 | 87.8789
b19M | +18.854 | +19.048 | P-2520 | 1 | 5 | 184.9 | 0.8 | 6 | 6181 | 6181 | 5.94776 | 0.0232158 | 182.244
b19M | +18.854 | +19.048 | P-2337 | 1 | 5 | 184.9 | 0.8 | 6 | 6181 | 6181 | 5.94776 | 0.0232158 | 182.244
2 x b19M | +18.854 | +19.048 | P-742 | 1 | 5 | 184.9 | 0.8 | 6 | 6181 | 6181 | 5.94776 | 0.0232158 | 182.244

# IfcBeam: H-198X99X4.5X7 (16)
In: Undefined
Description: H-198X99X4.5X7; Material: STEEL/SS400
Tekla Common - Phase: 1
Tekla Quantity - Volume: 0 m3; Area per tons: 43.2 m2; Height: 198 mm; Width: 99 mm
Pset_BeamCommon - LoadBearing: no
Name | Bottom elevation | Top elevation | Preliminary mark = Reference | Class | Weight (kg) | Gross footprint area (m2) | Net surface area (m2) | Tekla Quantity, Length (mm) | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
cb19 | +14.951 | +15.149 | P-2298 | 281 | 9.6 | 0.1 | 0.4 | 539.1 | 539.096 | 0.414708 | 0.00117754 | 9.24369
cb19 | +16.801 | +16.999 | P-2297 | 281 | 6.7 | 0 | 0.4 | 376.1 | 376.097 | 0.289318 | 0.000816661 | 6.41079
3 x cb19 | +14.951 | +15.149 | P-2298 | 5 | 9.6 | 0.1 | 0.4 | 539.1 | 539.096 | 0.414708 | 0.00117754 | 9.24369
3 x cb19 | +16.801 | +16.999 | P-2297 | 5 | 6.7 | 0 | 0.4 | 376.1 | 376.097 | 0.289318 | 0.000816661 | 6.41079
b19 | +19.142 | +19.342 | P-176 | 5 | 20.7 | 0 | 0.9 | 1170 | 1170.01 | 0.900044 | 0.00259039 | 20.3346
b19a | +19.199 | +19.399 | P-845 | 5 | 20.9 | 0 | 0.9 | 1173 | 1173.01 | 0.902352 | 0.00258512 | 20.2932
b19 | +19.255 | +19.455 | P-176 | 5 | 20.7 | 0 | 0.9 | 1170 | 1170.01 | 0.900044 | 0.00259039 | 20.3346
b19 | +19.358 | +19.558 | P-176 | 5 | 20.7 | 0 | 0.9 | 1170 | 1170.01 | 0.900044 | 0.00259039 | 20.3346
b19 | +18.850 | +19.048 | P-751 | 5 | 53.9 | 0.4 | 2.4 | 3024.9 | 3024.9 | 2.32695 | 0.00669714 | 52.5725
2 x b19 | +18.850 | +19.048 | P-750 | 5 | 41.4 | 0.2 | 1.8 | 2324.9 | 2324.9 | 1.78847 | 0.00514734 | 40.4066
b19 | +18.850 | +19.048 | P-1140 | 5 | 53.9 | 0.4 | 2.4 | 3024.9 | 3024.9 | 2.32695 | 0.00669714 | 52.5725

# IfcBeam: H-200X100X5.5X8, Hb20
In: Undefined
Description: H-200X100X5.5X8; Material: STEEL/SS400
Tekla Common - Bottom elevation: +3.225; Top elevation: +3.325; Preliminary mark: P-2796; Phase: 37; Class: 25
Tekla Quantity - Weight: 133.5 kg; Volume: 0 m3; Gross footprint area: 0.1 m2; Area per tons: 37 m2; Net surface area: 5 m2; Height: 200 mm; Width: 100 mm; Length: 6375 mm
Pset_BeamCommon - LoadBearing: no; Reference: P-2796
BaseQuantities - Length: 6375 mm; OuterSurfaceArea: 4.94231 m2; NetVolume: 0.0166515 m3; NetWeight: 130.714 kg

# IfcBeam: H-200X200X8X12 (7)
In: Undefined
Description: H-200X200X8X12; Material: STEEL/SS400
Tekla Common - Phase: 1; Class: 5
Tekla Quantity - Volume: 0 m3; Area per tons: 23.3 m2; Height: 200 mm; Width: 200 mm
Pset_BeamCommon - LoadBearing: no
Name | Bottom elevation | Top elevation | Preliminary mark = Reference | Weight (kg) | Gross footprint area (m2) | Net surface area (m2) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
b20W | +19.090 | +19.290 | P-2317 | 143.6 | 0.6 | 3.4 | 2880 | 3.34564 | 0.0177754 | 139.537
b20W | +19.090 | +19.290 | P-2316 | 58.3 | 0.2 | 1.4 | 1170 | 1.35917 | 0.00726336 | 57.0174
b20W | +14.170 | +14.370 | P-97 | 136.6 | 0.4 | 3.3 | 2740 | 3.18301 | 0.0170099 | 133.528
b20W | +14.170 | +14.370 | P-1222 | 375 | 1.4 | 8.9 | 7520 | 8.73584 | 0.0466842 | 366.471
b20W | +18.848 | +19.048 | P-585 | 150.8 | 0.6 | 3.6 | 3024 | 3.51292 | 0.018773 | 147.368
b20W | +9.670 | +9.870 | P-1222 | 375 | 1.4 | 8.9 | 7520 | 8.73584 | 0.0466842 | 366.471
b20W | +9.670 | +9.870 | P-97 | 136.6 | 0.4 | 3.3 | 2740 | 3.183 | 0.0170099 | 133.528

# IfcBeam: H-294X200X8X12 (2)
In: Undefined
Description: H-294X200X8X12; Material: STEEL/SS400
Tekla Common - Bottom elevation: +18.320; Top elevation: +18.520; Preliminary mark: P-1523; Phase: 7; Class: 27
Tekla Quantity - Weight: 575.6 kg; Volume: 0.1 m3; Gross footprint area: 0.2 m2; Area per tons: 24.2 m2; Net surface area: 14.2 m2; Height: 294 mm; Width: 200 mm; Length: 10320 mm
Pset_BeamCommon - LoadBearing: no; Reference: P-1523
BaseQuantities - Length: 10320 mm; OuterSurfaceArea: 13.9287 m2; NetVolume: 0.0718272 m3; NetWeight: 563.844 kg

# IfcBeam: H-346X174X6X9 (17)
In: Undefined
Description: H-346X174X6X9; Material: STEEL/SS400
Tekla Common - Phase: 1; Class: 5
Tekla Quantity - Area per tons: 32.9 m2; Height: 346 mm; Width: 174 mm
Pset_BeamCommon - LoadBearing: no
Name | Bottom elevation | Top elevation | Preliminary mark = Reference | Weight (kg) | Volume (m3) | Gross footprint area (m2) | Net surface area (m2) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
b38T | +14.024 | +14.370 | P-942 | 122.3 | 0 | 0.4 | 4.1 | 2970 | 4.02043 | 0.015147 | 118.904
b38T | +14.024 | +14.370 | P-133 | 118.6 | 0 | 0.4 | 4 | 2880 | 3.8986 | 0.014688 | 115.301
b38T | +14.024 | +14.370 | P-140 | 120.6 | 0 | 0.4 | 4 | 2930 | 3.96629 | 0.014943 | 117.303
5 x b38T | +14.024 | +14.370 | P-134 | 211.2 | 0 | 0.8 | 7.1 | 5130 | 6.94438 | 0.026163 | 205.38
b38T | +9.524 | +9.870 | P-590 | 431.5 | 0.1 | 1.8 | 14.4 | 10480 | 14.1866 | 0.053448 | 419.567
b38T | +9.524 | +9.870 | P-137 | 209.2 | 0 | 0.8 | 7 | 5080 | 6.8767 | 0.025908 | 203.378
b38T | +5.124 | +5.470 | P-589 | 309.6 | 0 | 1.2 | 10.4 | 7520 | 10.1797 | 0.038352 | 301.063
6 x b38T | +5.124 | +5.470 | P-137 | 209.2 | 0 | 0.8 | 7 | 5080 | 6.8767 | 0.025908 | 203.378

# IfcBeam: H-440X300X11X18 (14)
In: Undefined
Description: H-440X300X11X18
Tekla Common - Phase: 1
Tekla Quantity - Area per tons: 16.9 m2; Height: 440 mm; Width: 300 mm
Pset_BeamCommon - LoadBearing: no
Name | Material | Bottom elevation | Top elevation | Preliminary mark = Reference | Class | Weight (kg) | Volume (m3) | Gross footprint area (m2) | Net surface area (m2) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
G44M | STEEL/SN400B | +18.850 | +19.290 | P-1206 | 4 | 901.4 | 0.1 | 2.2 | 15.3 | 7461 | 15.1882 | 0.113136 | 888.114
cb44M | STEEL/SS400 | +18.850 | +19.290 | P-51 | 5 | 396.6 | 0.1 | 1 | 6.8 | 3283 | 6.68314 | 0.0499572 | 392.164
b44Mc | STEEL/SS400 | +19.065 | +19.725 | P-922 | 5 | 1266.7 | 0.2 | 0 | 21.6 | 10484.9 | 21.344 | 0.159677 | 1253.46
b44Ma | STEEL/SS400 | +18.850 | +19.505 | P-49 | 5 | 1266.7 | 0.2 | 0 | 21.6 | 10485.2 | 21.3445 | 0.159681 | 1253.5
cG44M | STEEL/SN400B | +18.850 | +19.290 | P-990 | 4 | 387.6 | 0 | 0.8 | 6.6 | 3208 | 6.53047 | 0.0483917 | 379.875
G44M | STEEL/SN400B | +19.065 | +19.725 | P-1137 | 4 | 1249.9 | 0.2 | 0 | 21.2 | 10345.5 | 21.0602 | 0.15656 | 1229 | Tekla Common - Finish: b
G44M | STEEL/SN400B | +18.850 | +19.505 | P-989 | 4 | 1249.9 | 0.2 | 0 | 21.2 | 10345.2 | 21.0596 | 0.156559 | 1228.98 | Tekla Common - Finish: a
G44M | STEEL/SN400B | +19.065 | +19.725 | P-1135 | 4 | 1249.9 | 0.2 | 0 | 21.2 | 10345.5 | 21.0602 | 0.156576 | 1229.12 | Tekla Common - Finish: h
G44M | STEEL/SN400B | +18.850 | +19.505 | P-1134 | 4 | 1249.9 | 0.2 | 0 | 21.2 | 10345.2 | 21.0596 | 0.156574 | 1229.11 | Tekla Common - Finish: g
cG44M | STEEL/SN400B | +18.850 | +19.290 | P-42 | 4 | 170.1 | 0 | 0.4 | 2.9 | 1408 | 2.86624 | 0.0209525 | 164.477
cG44M | STEEL/SN400B | +19.065 | +19.505 | P-42 | 4 | 170.1 | 0 | 0.4 | 2.9 | 1408 | 2.86624 | 0.0209525 | 164.477
2 x G44M | STEEL/SN400B | +19.065 | +19.505 | P-987 | 4 | 1466.2 | 0.2 | 3.6 | 24.9 | 12136 | 24.705 | 0.183979 | 1444.24
G44M | STEEL/SN400B | +18.850 | +19.290 | P-987 | 4 | 1466.2 | 0.2 | 3.6 | 24.9 | 12136 | 24.705 | 0.183979 | 1444.24

# IfcBeam: H-692X300X13X20 (8)
In: Undefined
Description: H-692X300X13X20; Material: STEEL/SM490A
Tekla Common - Phase: 1; Class: 4
Tekla Quantity - Volume: 0.1 m3; Area per tons: 15.4 m2; Height: 692 mm; Width: 300 mm
Pset_BeamCommon - LoadBearing: no
Name | Bottom elevation | Top elevation | Preliminary mark = Reference | Weight (kg) | Gross footprint area (m2) | Net surface area (m2) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
2 x cG69M | +13.678 | +14.370 | P-1288 | 472 | 0.8 | 7.4 | 2898 | 7.32353 | 0.0587409 | 461.116 | Tekla Common - Finish: a
cG69M | +13.678 | +14.370 | P-1110 | 506.3 | 0.8 | 7.9 | 3108 | 7.85422 | 0.0630408 | 494.87 | Tekla Common - Finish: a
cG69M | +9.178 | +9.870 | P-549 | 795.4 | 1.4 | 12.5 | 4883 | 12.3398 | 0.0994502 | 780.684
2 x cG69M | +4.778 | +5.470 | P-241 | 774.2 | 1.4 | 12.1 | 4753 | 12.0113 | 0.0967238 | 759.282
cG69M | +13.678 | +14.370 | P-412 | 506.3 | 0.8 | 7.9 | 3108 | 7.85422 | 0.0630408 | 494.87
cG69M | +9.178 | +9.870 | P-411 | 765.4 | 1.4 | 11.7 | 4699 | 11.8748 | 0.093376 | 733.001

# IfcBeam: H-700X300X13X24 (19)
In: Undefined
Description: H-700X300X13X24; Material: STEEL/SN490B
Tekla Common - Phase: 1; Class: 4
Tekla Quantity - Area per tons: 14 m2; Height: 700 mm; Width: 300 mm
Pset_BeamCommon - LoadBearing: no
Name | Bottom elevation | Top elevation | Preliminary mark = Reference | Weight (kg) | Volume (m3) | Gross footprint area (m2) | Net surface area (m2) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
G70M | +4.770 | +5.470 | P-542 | 1366.4 | 0.2 | 2.2 | 19.3 | 7519 | 19.1216 | 0.171078 | 1342.96
3 x G70M | +13.670 | +14.370 | P-446 | 1878.3 | 0.2 | 3.1 | 26.5 | 10336 | 26.2855 | 0.235007 | 1844.81
G70M | +9.170 | +9.870 | P-1692 | 1869.2 | 0.2 | 3.1 | 25.7 | 10286 | 26.1583 | 0.228718 | 1795.44
G70M | +4.770 | +5.470 | P-32 | 1869.2 | 0.2 | 3.1 | 26.5 | 10286 | 26.1583 | 0.233863 | 1835.83
G70M | +13.670 | +14.370 | P-2017 | 1878.3 | 0.2 | 3.1 | 26.1 | 10336 | 26.2855 | 0.231926 | 1820.62 | Tekla Common - Finish: a
G70M | +9.170 | +9.870 | P-445 | 1869.2 | 0.2 | 3.1 | 26.5 | 10286 | 26.1583 | 0.234017 | 1837.03
G70M | +9.170 | +9.870 | P-1691 | 1869.2 | 0.2 | 3.1 | 26 | 10286 | 26.1583 | 0.23107 | 1813.9 | Tekla Common - Finish: a
G70M | +4.770 | +5.470 | P-539 | 497.8 | 0.1 | 0.8 | 7 | 2739 | 6.96554 | 0.0617304 | 484.584
G70M | +4.770 | +5.470 | P-1568 | 1869.2 | 0.2 | 3.1 | 25.7 | 10286 | 26.1583 | 0.229393 | 1800.74 | Tekla Common - Finish: a
G70M | +13.670 | +14.370 | P-2009 | 2205.4 | 0.3 | 3.6 | 30 | 12136 | 30.863 | 0.267954 | 2103.44
G70M | +9.170 | +9.870 | P-1684 | 2196.4 | 0.3 | 3.6 | 29.7 | 12086 | 30.7359 | 0.265956 | 2087.75
G70M | +9.170 | +9.870 | P-1683 | 2196.4 | 0.3 | 3.6 | 30 | 12086 | 30.7359 | 0.267244 | 2097.86 | Tekla Common - Finish: a
G70M | +4.770 | +5.470 | P-1564 | 2196.4 | 0.3 | 3.6 | 30.9 | 12086 | 30.7359 | 0.273953 | 2150.53 | Tekla Common - Finish: a
G70M | +9.170 | +9.870 | P-1099 | 2196.4 | 0.3 | 3.6 | 30.9 | 12086 | 30.7359 | 0.275193 | 2160.27 | Tekla Common - Finish: a
G70M | +9.170 | +9.870 | P-1094 | 2196.4 | 0.3 | 3.6 | 30.9 | 12086 | 30.7359 | 0.275193 | 2160.27 | Tekla Common - Finish: b
G70M | +4.770 | +5.470 | P-1098 | 2196.4 | 0.3 | 3.6 | 30.9 | 12086 | 30.7359 | 0.27504 | 2159.07 | Tekla Common - Finish: a
G70M | +4.770 | +5.470 | P-1093 | 2196.4 | 0.3 | 3.6 | 30.9 | 12086 | 30.7359 | 0.27504 | 2159.07 | Tekla Common - Finish: b

# IfcBeam: L-75X75X6 (102)
In: Undefined
Description: L-75X75X6; Material: STEEL/SS400
Tekla Common - Phase: 1
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 42.8 m2; Net surface area: 0.1 m2; Height: 75 mm; Width: 75 mm
Pset_BeamCommon - LoadBearing: no
Name | Bottom elevation | Top elevation | Preliminary mark = Reference | Class | Weight (kg) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
DL | +14.271 | +14.346 | DL-11 | 36 | 2.3 | 330 | 0.0966629 | 0.00028512 | 2.23819
DL | +9.771 | +9.846 | DL-11 | 36 | 2.3 | 330 | 0.0966629 | 0.00028512 | 2.23819
10 x DL | +9.775 | +9.850 | DL-3 | 36 | 2.6 | 385 | 0.112773 | 0.00033264 | 2.61122
34 x DL | +9.771 | +9.846 | DL-3 | 36 | 2.6 | 385 | 0.112773 | 0.00033264 | 2.61122
5 x DL | +5.375 | +5.450 | DL-3 | 36 | 2.6 | 385 | 0.112773 | 0.00033264 | 2.61122
DL | +5.371 | +5.446 | DL-11 | 36 | 2.3 | 330 | 0.0966629 | 0.00028512 | 2.23819
34 x DL | +5.371 | +5.446 | DL-3 | 36 | 2.6 | 385 | 0.112773 | 0.00033264 | 2.61122
2 x L75 | +10.745 | +10.820 | P-494 | 99 | 2.8 | 404 | 0.118339 | 0.000349056 | 2.74009
2 x L75 | +10.670 | +10.745 | P-494 | 99 | 2.8 | 404 | 0.118339 | 0.000349056 | 2.74009
2 x L75 | +10.977 | +11.052 | P-494 | 99 | 2.8 | 404 | 0.118339 | 0.000349056 | 2.74009
2 x L75 | +10.902 | +10.977 | P-494 | 99 | 2.8 | 404 | 0.118339 | 0.000349056 | 2.74009
2 x L75 | +10.745 | +10.820 | P-495 | 99 | 2.8 | 410 | 0.120096 | 0.00035424 | 2.78078
2 x L75 | +10.670 | +10.745 | P-495 | 99 | 2.8 | 410 | 0.120096 | 0.00035424 | 2.78078
2 x L75 | +10.977 | +11.052 | P-495 | 99 | 2.8 | 410 | 0.120096 | 0.00035424 | 2.78078
2 x L75 | +10.902 | +10.977 | P-495 | 99 | 2.8 | 410 | 0.120096 | 0.00035424 | 2.78078

# IfcBeam: L-90X90X7 (2)
In: Undefined
Description: L-90X90X7; Material: STEEL/SS400
Tekla Common - Bottom elevation: +14.280; Top elevation: +14.370; Preliminary mark: P-2703; Phase: 1; Class: 281
Tekla Quantity - Weight: 6.9 kg; Volume: 0 m3; Gross footprint area: 0.1 m2; Area per tons: 36.6 m2; Net surface area: 0.4 m2; Height: 90 mm; Width: 90 mm; Length: 720 mm
Pset_BeamCommon - LoadBearing: no; Reference: P-2703
BaseQuantities - Length: 720 mm; OuterSurfaceArea: 0.25302 m2; NetVolume: 0.00087192 m3; NetWeight: 6.84457 kg

# IfcBeam: M20 (6)
In: Undefined
Description: M20; Material: STEEL/SNR400B
Tekla Common - Phase: 7; Class: 7
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 25.5 m2; Net surface area: 0.4 m2; Height: 20 mm; Width: 20 mm
Pset_BeamCommon - LoadBearing: no
Name | Bottom elevation | Top elevation | Preliminary mark = Reference | Weight (kg) | Tekla Quantity, Length (mm) | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
V1 | +17.087 | +18.585 | P-2551 | 15.6 | 6329 | 6328.99 | 0.397663 | 0.00179011 | 14.0523
V1 | +17.087 | +18.585 | P-2551 | 15.6 | 6329 | 6329.01 | 0.397664 | 0.00179011 | 14.0524
2 x V1 | +17.140 | +18.585 | P-2552 | 15.3 | 6199 | 6199 | 0.389495 | 0.00175334 | 13.7637
V1 | +18.433 | +18.893 | P-2575 | 11.9 | 4851.1 | 4851.14 | 0.304807 | 0.00137211 | 10.7711
V1 | +18.433 | +18.793 | P-2204 | 11.7 | 4758.8 | 4758.82 | 0.299006 | 0.001346 | 10.5661

# IfcBeam: M27 (18)
In: Undefined
Description: M27; Material: STEEL/SNR400B
Tekla Common - Phase: 1; Class: 7
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 18.9 m2; Height: 27 mm; Width: 27 mm
Pset_BeamCommon - LoadBearing: no
Name | Bottom elevation | Top elevation | Preliminary mark = Reference | Weight (kg) | Net surface area (m2) | Tekla Quantity, Length (mm) | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
2 x H1 | +19.439 | +19.500 | P-1366 | 14.4 | 0.4 | 3196.7 | 3196.69 | 0.271153 | 0.00174779 | 13.7202
2 x H1 | +19.269 | +19.344 | P-1366 | 14.4 | 0.4 | 3197.1 | 3197.06 | 0.271185 | 0.00174799 | 13.7218
2 x H1 | +19.328 | +19.401 | P-1367 | 15.3 | 0.4 | 3404.9 | 3404.91 | 0.288815 | 0.00186163 | 14.6138
3 x H1 | +19.384 | +19.457 | P-1367 | 15.3 | 0.4 | 3404.9 | 3404.91 | 0.288815 | 0.00186163 | 14.6138
H1 | +19.328 | +19.401 | P-1367 | 15.3 | 0.4 | 3405.1 | 3405.1 | 0.288831 | 0.00186174 | 14.6147
H1 | +19.439 | +19.500 | P-1366 | 14.4 | 0.4 | 3196.7 | 3196.7 | 0.271154 | 0.0017478 | 13.7202
H1 | +19.269 | +19.344 | P-1366 | 14.4 | 0.4 | 3197.1 | 3197.07 | 0.271185 | 0.001748 | 13.7218
2 x H1 | +19.544 | +19.618 | P-1367 | 15.3 | 0.4 | 3404.9 | 3405.01 | 0.288823 | 0.00186169 | 14.6142
2 x H1 | +19.484 | +19.560 | P-1366 | 14.4 | 0.4 | 3197 | 3196.99 | 0.271178 | 0.00174795 | 13.7214
H1 | +19.544 | +19.585 | P-1434 | 4.8 | 0.1 | 1066.3 | 1066.31 | 0.0904475 | 0.000583004 | 4.57658
H1 | +19.484 | +19.560 | P-1366 | 14.4 | 0.4 | 3196.7 | 3196.69 | 0.271153 | 0.00174779 | 13.7201

# IfcBeam: PL14*15 (48)
In: Undefined
Description: PL14*15; Material: STEEL/SN490B
Tekla Common - Phase: 1; Class: 99
Tekla Quantity - Weight: 0.4 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 37.8 m2; Net surface area: 0 m2; Height: 15 mm; Width: 14 mm; Length: 205 mm
Pset_BeamCommon - LoadBearing: no
BaseQuantities - Length: 205 mm; OuterSurfaceArea: 0.0107698 m2; NetVolume: 0.0000362483 m3; NetWeight: 0.284549 kg
Name | Bottom elevation | Top elevation | Reference
3 x HiRing3 | +14.321 | +14.335 | 150S-1
3 x HiRing3 | +13.705 | +13.719 | 150S-1
3 x HiRing3 | +14.317 | +14.331 | 150S-1
3 x HiRing3 | +13.709 | +13.723 | 150S-1
HiRing3 | +14.309 | +14.323 | 150R+S-4
HiRing3 | +13.717 | +13.731 | 150R+S-4
3 x HiRing3 | +9.811 | +9.825 | 150S-1
3 x HiRing3 | +9.215 | +9.229 | 150S-1
5 x HiRing3 | +9.821 | +9.835 | 150S-1
5 x HiRing3 | +9.205 | +9.219 | 150S-1
2 x HiRing3 | +9.813 | +9.827 | 150S-1
2 x HiRing3 | +9.221 | +9.235 | 150S-1
HiRing3 | +9.809 | +9.823 | 150R+S-2
HiRing3 | +9.217 | +9.231 | 150R+S-2
6 x HiRing3 | +5.421 | +5.435 | 150S-1
6 x HiRing3 | +4.805 | +4.819 | 150S-1

# IfcBeam: PL16*200 (5)
In: Undefined
Description: PL16*200; Material: STEEL/SS400
Tekla Common - Bottom elevation: +14.800; Top elevation: +14.816; Phase: 1
Tekla Quantity - Weight: 5 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 18.5 m2; Net surface area: 0.1 m2; Height: 200 mm; Width: 16 mm; Length: 200 mm
Pset_BeamCommon - LoadBearing: no
BaseQuantities - Length: 200 mm; OuterSurfaceArea: 0.0928 m2; NetVolume: 0.00064 m3; NetWeight: 5.024 kg
Name | Preliminary mark | Class | Reference
BASEPLATE | K72-33 | 292 | KG-55
BASEPLATE | K72-33 | 282 | K72-33
3 x BASEPLATE | K72-20 | 314 | K72-20

# IfcBeam: PL16*21 (14)
In: Undefined
Description: PL16*21; Material: STEEL/SN490B
Tekla Common - Phase: 1; Class: 99
Tekla Quantity - Weight: 0.6 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 29.9 m2; Net surface area: 0 m2; Height: 21 mm; Width: 16 mm; Length: 260 mm
Pset_BeamCommon - LoadBearing: no; Reference: 200S-1
BaseQuantities - Length: 260 mm; OuterSurfaceArea: 0.0176591 m2; NetVolume: 0.0000752 m3; NetWeight: 0.59032 kg
Name | Bottom elevation | Top elevation
7 x HiRing3 | +9.819 | +9.835
7 x HiRing3 | +9.205 | +9.221

# IfcBeam: PL16*300, BASEPLATE
In: Undefined
Description: PL16*300; Material: STEEL/SS400
Tekla Common - Bottom elevation: -0.550; Top elevation: -0.534; Preliminary mark: F-11; Phase: 37; Class: 314
Tekla Quantity - Weight: 15.1 kg; Volume: 0 m3; Gross footprint area: 0.1 m2; Area per tons: 17.4 m2; Net surface area: 0.4 m2; Height: 300 mm; Width: 16 mm; Length: 400 mm
Pset_BeamCommon - LoadBearing: no; Reference: F-11
BaseQuantities - Length: 400 mm; OuterSurfaceArea: 0.2624 m2; NetVolume: 0.00192 m3; NetWeight: 15.072 kg

# IfcBeam: PL16X38 (64)
In: Undefined
Description: PL16X38; Material: STEEL/SS400
Tekla Common - Phase: 1; Class: 315
Tekla Quantity - Weight: 0.1 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 31.8 m2; Net surface area: 0 m2; Height: 38 mm; Width: 16 mm; Length: 28 mm
Pset_BeamCommon - LoadBearing: no; Reference: P-1453
BaseQuantities - Length: 28 mm; OuterSurfaceArea: 0.00424 m2; NetVolume: 0.000017024 m3; NetWeight: 0.133638 kg
Name | Bottom elevation | Top elevation
8 x PLATE | +18.288 | +18.326 | Tekla Common - Preliminary mark: P-1453
8 x PLATE | +18.073 | +18.111 | Tekla Common - Preliminary mark: P-1453
16 x PLATE | +12.893 | +12.931 | Tekla Common - Preliminary mark: P-1453
16 x PLATE | +8.393 | +8.431
16 x PLATE | +3.993 | +4.031

# IfcBeam: PL20*23 (12)
In: Undefined
Description: PL20*23; Material: STEEL/SN490B
Tekla Common - Phase: 1; Class: 99
Tekla Quantity - Weight: 0.9 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 25.2 m2; Net surface area: 0 m2; Height: 23 mm; Width: 20 mm; Length: 310 mm
Pset_BeamCommon - LoadBearing: no
BaseQuantities - Length: 310 mm; OuterSurfaceArea: 0.0248759 m2; NetVolume: 0.000126 m3; NetWeight: 0.9891 kg
Name | Bottom elevation | Top elevation | Reference
2 x HiRing3 | +14.315 | +14.335 | 250S-1
2 x HiRing3 | +13.705 | +13.725 | 250S-1
HiRing3 | +14.303 | +14.323 | 250R+S-5
HiRing3 | +13.717 | +13.737 | 250R+S-5
HiRing3 | +9.815 | +9.835 | 250S-1
HiRing3 | +9.205 | +9.225 | 250S-1
2 x HiRing3 | +5.415 | +5.435 | 250S-1
2 x HiRing3 | +4.805 | +4.825 | 250S-1

# IfcBeam: PL25*30 (6)
In: Undefined
Description: PL25*30; Material: STEEL/SN490B
Tekla Common - Phase: 1; Class: 99
Tekla Quantity - Weight: 2.2 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 19.5 m2; Net surface area: 0 m2; Height: 30 mm; Width: 25 mm; Length: 410 mm
Pset_BeamCommon - LoadBearing: no; Reference: 350S-1
BaseQuantities - Length: 410 mm; OuterSurfaceArea: 0.0429134 m2; NetVolume: 0.00028 m3; NetWeight: 2.198 kg
Name | Bottom elevation | Top elevation
HiRing3 | +14.310 | +14.335
HiRing3 | +13.705 | +13.730
HiRing3 | +14.306 | +14.331
HiRing3 | +13.709 | +13.734
HiRing3 | +9.800 | +9.825
HiRing3 | +9.215 | +9.240

# IfcBeam: PL28*30 (6)
In: Undefined
Description: PL28*30; Material: STEEL/SN490B
Tekla Common - Phase: 1; Class: 99
Tekla Quantity - Weight: 2.8 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 18.3 m2; Net surface area: 0.1 m2; Height: 30 mm; Width: 28 mm; Length: 465 mm
Pset_BeamCommon - LoadBearing: no; Reference: 400S-2
BaseQuantities - Length: 465 mm; OuterSurfaceArea: 0.0513944 m2; NetVolume: 0.000357233 m3; NetWeight: 2.80428 kg
Name | Bottom elevation | Top elevation
2 x HiRing3 | +9.797 | +9.825
2 x HiRing3 | +9.215 | +9.243
HiRing3 | +9.799 | +9.827
HiRing3 | +9.221 | +9.249

# IfcBeam: PL6*140 (2)
In: Undefined
Description: PL6*140; Material: STEEL/SS400
Tekla Common - Preliminary mark: SP-18; Phase: 1; Class: 314
Tekla Quantity - Weight: 1.1 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 45.8 m2; Net surface area: 0.1 m2; Height: 140 mm; Width: 6 mm; Length: 167 mm
Pset_BeamCommon - LoadBearing: no; Reference: SP-18
BaseQuantities - Length: 167 mm; OuterSurfaceArea: 0.050444 m2; NetVolume: 0.00014028 m3; NetWeight: 1.1012 kg
Name | Bottom elevation | Top elevation
SPLICE | +19.229 | +19.369
SPLICE | +19.228 | +19.368

# IfcBeam: PL6*560 (4)
In: Undefined
Description: PL6*560; Material: STEEL/SN490B
Tekla Common - Bottom elevation: +13.740; Top elevation: +14.300; Preliminary mark: SP-17; Phase: 1; Class: 314
Tekla Quantity - Weight: 4.4 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 44.4 m2; Net surface area: 0.2 m2; Height: 560 mm; Width: 6 mm; Length: 167 mm
Pset_BeamCommon - LoadBearing: no; Reference: SP-17
BaseQuantities - Length: 167 mm; OuterSurfaceArea: 0.195764 m2; NetVolume: 0.00056112 m3; NetWeight: 4.40479 kg

# IfcBeam: PL60*900, BASEPLATE
In: Undefined
Description: PL60*900; Material: STEEL/TMCP325C
Tekla Common - Bottom elevation: -0.450; Top elevation: -0.390; Preliminary mark: K1-79; Phase: 1; Class: 314
Tekla Quantity - Weight: 370.1 kg; Volume: 0 m3; Gross footprint area: 0.8 m2; Area per tons: 4.8 m2; Net surface area: 1.8 m2; Height: 900 mm; Width: 60 mm; Length: 900 mm
Pset_BeamCommon - LoadBearing: no; Reference: K1-79
BaseQuantities - Length: 900 mm; OuterSurfaceArea: 1.77214 m2; NetVolume: 0.047148 m3; NetWeight: 370.112 kg

# IfcBeam: PL9*120, ENDPLATE
In: Undefined
Description: PL9*120; Material: STEEL/SS400
Tekla Common - Bottom elevation: +3.186; Top elevation: +3.195; Preliminary mark: F-6; Phase: 37; Class: 314
Tekla Quantity - Weight: 1.6 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 33.8 m2; Net surface area: 0.1 m2; Height: 120 mm; Width: 9 mm; Length: 220 mm
Pset_BeamCommon - LoadBearing: no; Reference: F-6
BaseQuantities - Length: 220 mm; OuterSurfaceArea: 0.05344 m2; NetVolume: 0.0002016 m3; NetWeight: 1.58256 kg

# IfcBeam: PL9*320 (4)
In: Undefined
Description: PL9*320; Material: STEEL/SS400
Tekla Common - Bottom elevation: +18.910; Top elevation: +19.230; Preliminary mark: SP-16; Phase: 1; Class: 314
Tekla Quantity - Weight: 3.8 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 30.6 m2; Net surface area: 0.1 m2; Height: 320 mm; Width: 9 mm; Length: 167 mm
Pset_BeamCommon - LoadBearing: no; Reference: SP-16
BaseQuantities - Length: 167 mm; OuterSurfaceArea: 0.115646 m2; NetVolume: 0.00048096 m3; NetWeight: 3.77554 kg

# IfcBeam: PL9*500 (16)
In: Undefined
Description: PL9*500; Material: STEEL/SS400
Tekla Common - Bottom elevation: +13.770; Top elevation: +14.270; Preliminary mark: SP-12; Phase: 1; Class: 314
Tekla Quantity - Weight: 5.8 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 30.3 m2; Net surface area: 0.2 m2; Height: 500 mm; Width: 9 mm; Length: 167 mm
Pset_BeamCommon - LoadBearing: no; Reference: SP-12
BaseQuantities - Length: 167 mm; OuterSurfaceArea: 0.179006 m2; NetVolume: 0.0007515 m3; NetWeight: 5.89928 kg

# IfcBeam: PL9X65 (32)
In: Undefined
Description: PL9X65; Material: STEEL/SS400
Tekla Common - Phase: 1; Class: 315
Tekla Quantity - Weight: 1.8 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 32.9 m2; Net surface area: 0.1 m2; Height: 65 mm; Width: 9 mm; Length: 400 mm
Pset_BeamCommon - LoadBearing: no; Reference: P-1452
BaseQuantities - Length: 400 mm; OuterSurfaceArea: 0.06037 m2; NetVolume: 0.000234 m3; NetWeight: 1.8369 kg
Name | Bottom elevation | Top elevation
4 x PLATE | +18.288 | +18.353 | Tekla Common - Preliminary mark: P-1452
4 x PLATE | +18.073 | +18.138 | Tekla Common - Preliminary mark: P-1452
8 x PLATE | +12.893 | +12.958 | Tekla Common - Preliminary mark: P-1452
8 x PLATE | +8.393 | +8.458
8 x PLATE | +3.993 | +4.058

# IfcBeam: SH-700X200X9X12 (32)
In: Undefined
Description: SH-700X200X9X12; Material: STEEL/SS400
Tekla Common - Phase: 1; Class: 5
Tekla Quantity - Height: 700 mm; Width: 200 mm
Pset_BeamCommon - LoadBearing: no
Name | Bottom elevation | Top elevation | Preliminary mark = Reference | Weight (kg) | Volume (m3) | Gross footprint area (m2) | Area per tons (m2) | Net surface area (m2) | Tekla Quantity, Length (mm) | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
b71 | +13.670 | +14.370 | P-339 | 256.7 | 0 | 0.6 | 25 | 6.4 | 2930 | 2930 | 6.41503 | 0.0318901 | 250.337
cb71 | +13.670 | +14.370 | P-958 | 260.5 | 0 | 0.6 | 25 | 6.4 | 2973 | 2973 | 6.50355 | 0.0323209 | 253.719
3 x cb71 | +13.670 | +14.370 | P-807 | 278.8 | 0 | 0.6 | 25 | 7 | 3183 | 3183 | 6.96177 | 0.0346066 | 271.662
b71 | +13.670 | +14.370 | P-575 | 816.5 | 0.1 | 1.9 | 25 | 20.4 | 9320 | 9320 | 20.358 | 0.101439 | 796.295
b71 | +13.670 | +14.370 | P-78 | 252.3 | 0 | 0.6 | 25 | 6.4 | 2880 | 2880 | 6.30593 | 0.0313459 | 246.065
b71 | +13.670 | +14.370 | P-103 | 756 | 0.1 | 1.8 | 25 | 18.9 | 8630 | 8630 | 18.8524 | 0.0939289 | 737.342
b71 | +13.670 | +14.370 | P-2078 | 449.4 | 0.1 | 1 | 25 | 11.2 | 5130 | 5130 | 11.1847 | 0.0556777 | 437.07
b71 | +13.670 | +14.370 | P-2077 | 449.4 | 0.1 | 1 | 25 | 11.2 | 5130 | 5130 | 11.1847 | 0.0556777 | 437.07
b71a | +13.670 | +14.370 | P-848 | 449.7 | 0.1 | 1 | 24.7 | 11.2 | 5133 | 5133 | 11.1552 | 0.0555159 | 435.8
b71 | +13.670 | +14.370 | P-2074 | 528.3 | 0.1 | 1.2 | 24.5 | 12.9 | 6030 | 6029.99 | 12.8769 | 0.0641748 | 503.772
b71a | +13.670 | +14.370 | P-2073 | 918.4 | 0.1 | 2.1 | 24.2 | 22.3 | 10483 | 10483 | 22.2543 | 0.111007 | 871.405
b71a | +13.670 | +14.370 | P-2072 | 918.4 | 0.1 | 2.1 | 24.5 | 22.4 | 10483 | 10483 | 22.3749 | 0.111537 | 875.566
b71a | +13.670 | +14.370 | P-2071 | 918.4 | 0.1 | 2.1 | 24.7 | 22.7 | 10483 | 10483 | 22.7982 | 0.113588 | 891.666
b71 | +9.170 | +9.870 | P-341 | 523.9 | 0.1 | 1.2 | 25 | 13.1 | 5980 | 5979.99 | 13.0701 | 0.0650863 | 510.927
2 x b71 | +9.170 | +9.870 | P-1738 | 445 | 0.1 | 1 | 24.6 | 10.9 | 5080 | 5080 | 10.9257 | 0.0544145 | 427.154
b71 | +9.170 | +9.870 | P-1736 | 445 | 0.1 | 1 | 24.5 | 10.9 | 5080 | 5080 | 10.895 | 0.0542573 | 425.92
b71 | +9.170 | +9.870 | P-340 | 445 | 0.1 | 1 | 25 | 11.2 | 5080 | 5080 | 11.1063 | 0.0552907 | 434.032
b71 | +9.170 | +9.870 | P-1734 | 445 | 0.1 | 1 | 24.6 | 10.9 | 5080 | 5080 | 10.9288 | 0.0544159 | 427.165
b71 | +9.170 | +9.870 | P-1924 | 445 | 0.1 | 1 | 24.2 | 10.9 | 5080 | 5080 | 10.7937 | 0.0537825 | 422.192
2 x b71 | +9.170 | +9.870 | P-1733 | 918.1 | 0.1 | 2.1 | 24.7 | 22.7 | 10480 | 10480 | 22.6809 | 0.113032 | 887.303
b71 | +9.170 | +9.870 | P-1731 | 918.1 | 0.1 | 2.1 | 24.6 | 22.6 | 10480 | 10480 | 22.6018 | 0.112632 | 884.159
b71 | +4.770 | +5.470 | P-572 | 249.2 | 0 | 0.6 | 25 | 6.2 | 2845 | 2844.99 | 6.22953 | 0.0309648 | 243.074
b71 | +4.770 | +5.470 | P-340 | 445 | 0.1 | 1 | 25 | 11.2 | 5080 | 5080 | 11.1063 | 0.0552907 | 434.032
b71 | +4.770 | +5.470 | P-1595 | 445 | 0.1 | 1 | 25 | 11.2 | 5080 | 5080 | 11.0756 | 0.0551335 | 432.798
b71 | +4.770 | +5.470 | P-1594 | 445 | 0.1 | 1 | 25 | 11.2 | 5080 | 5080 | 11.0756 | 0.0551335 | 432.798
b71 | +4.770 | +5.470 | P-1590 | 918.1 | 0.1 | 2.1 | 24.7 | 22.7 | 10480 | 10480 | 22.7663 | 0.113435 | 890.468
b71 | +4.770 | +5.470 | P-1589 | 918.1 | 0.1 | 2.1 | 24.7 | 22.7 | 10480 | 10480 | 22.7663 | 0.113435 | 890.468
b71 | +4.770 | +5.470 | P-1588 | 918.1 | 0.1 | 2.1 | 24.6 | 22.6 | 10480 | 10480 | 22.5857 | 0.112559 | 883.59

# IfcBeam: SH-700X200X9X16 (8)
In: Undefined
Description: SH-700X200X9X16; Material: STEEL/SN490B
Tekla Common - Phase: 1; Class: 5
Tekla Quantity - Height: 700 mm; Width: 200 mm
Pset_BeamCommon - LoadBearing: no
Name | Bottom elevation | Top elevation | Preliminary mark = Reference | Weight (kg) | Volume (m3) | Gross footprint area (m2) | Area per tons (m2) | Net surface area (m2) | Tekla Quantity, Length (mm) | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
cb72 | +13.670 | +14.370 | P-951 | 317.1 | 0 | 0.6 | 21.9 | 7 | 3183 | 3183 | 6.96391 | 0.0394545 | 309.718
b72c | +13.670 | +14.370 | P-2049 | 601 | 0.1 | 1.2 | 21.1 | 12.7 | 6033 | 6033.01 | 12.6704 | 0.0723715 | 568.116
b72c | +13.670 | +14.370 | P-2048 | 1044.3 | 0.1 | 2.1 | 21.7 | 22.7 | 10483 | 10483 | 22.6805 | 0.129045 | 1013
b72c | +13.670 | +14.370 | P-2046 | 1044.3 | 0.1 | 2.1 | 21.7 | 22.7 | 10483 | 10483 | 22.7408 | 0.12931 | 1015.08
b72c | +9.170 | +9.870 | P-1715 | 1044.3 | 0.1 | 2.1 | 21.9 | 22.7 | 10483 | 10483 | 22.8311 | 0.129748 | 1018.52
b72c | +4.770 | +5.470 | P-1599 | 1044.3 | 0.1 | 2.1 | 21.9 | 22.9 | 10483 | 10483 | 22.8618 | 0.129905 | 1019.75
2 x b72c | +4.770 | +5.470 | P-115 | 1044.3 | 0.1 | 2.1 | 21.9 | 22.9 | 10483 | 10483 | 22.8925 | 0.130062 | 1020.99

# IfcBeam: SH-700X300X12X22 (5)
In: Undefined
Description: SH-700X300X12X22; Material: STEEL/SN490B
Tekla Common - Phase: 1; Class: 5
Tekla Quantity - Height: 700 mm; Width: 300 mm
Pset_BeamCommon - LoadBearing: no
Name | Bottom elevation | Top elevation | Preliminary mark = Reference | Weight (kg) | Volume (m3) | Gross footprint area (m2) | Area per tons (m2) | Net surface area (m2) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
cb75 | +9.170 | +9.870 | P-1720 | 835.1 | 0.1 | 1.4 | 14.9 | 12.5 | 4983 | 12.546 | 0.102748 | 806.573
b75c | +9.170 | +9.870 | P-1719 | 1011.1 | 0.1 | 1.8 | 14.9 | 15 | 6033 | 15.0141 | 0.123352 | 968.314
b75c | +9.170 | +9.870 | P-162 | 1756.9 | 0.2 | 3.1 | 15.4 | 27 | 10483 | 27.0369 | 0.220773 | 1733.07
cb75 | +4.770 | +5.470 | P-1604 | 813.4 | 0.1 | 1.4 | 15.4 | 12.5 | 4853 | 12.4048 | 0.101295 | 795.168
b75c | +4.770 | +5.470 | P-161 | 1011.1 | 0.1 | 1.8 | 15.4 | 15.6 | 6033 | 15.5737 | 0.127003 | 996.974

# IfcBeam: SH-700X300X14X32 (5)
In: Undefined
Description: SH-700X300X14X32; Material: STEEL/SN490B
Tekla Common - Phase: 1; Class: 4
Tekla Quantity - Height: 700 mm; Width: 300 mm
Pset_BeamCommon - LoadBearing: no
Name | Bottom elevation | Top elevation | Preliminary mark = Reference | Weight (kg) | Volume (m3) | Gross footprint area (m2) | Area per tons (m2) | Net surface area (m2) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
G74 | +4.770 | +5.470 | P-554 | 1342.3 | 0.2 | 1.8 | 11.5 | 15.5 | 6025 | 15.4677 | 0.16801 | 1318.88 | Tekla Common - Finish: a
G74 | +9.170 | +9.870 | P-1696 | 2291.5 | 0.3 | 3.1 | 11.2 | 25.6 | 10286 | 25.6482 | 0.281664 | 2211.06
G74 | +4.770 | +5.470 | P-28 | 2291.5 | 0.3 | 3.1 | 11.5 | 26.5 | 10286 | 26.3784 | 0.287096 | 2253.71
G74 | +13.670 | +14.370 | P-2028 | 2703.7 | 0.3 | 3.6 | 11 | 29.7 | 12136 | 29.7462 | 0.328411 | 2578.03
G74 | +13.670 | +14.370 | P-1078 | 2703.7 | 0.3 | 3.6 | 11.5 | 31.1 | 12136 | 31.1366 | 0.339089 | 2661.85 | Tekla Common - Finish: a

# IfcBeam: SH-700X300X16X36, G75D
In: Undefined
Description: SH-700X300X16X36; Material: STEEL/SN490B
Tekla Common - Bottom elevation: +13.670; Top elevation: +14.370; Preliminary mark: P-438; Phase: 1; Class: 4
Tekla Quantity - Weight: 2847.9 kg; Volume: 0.3 m3; Gross footprint area: 3.4 m2; Area per tons: 10.1 m2; Net surface area: 29.2 m2; Height: 700 mm; Width: 300 mm; Length: 11362 mm
Pset_BeamCommon - LoadBearing: no; Reference: P-438
BaseQuantities - Length: 11362 mm; OuterSurfaceArea: 29.1553 m2; NetVolume: 0.358104 m3; NetWeight: 2811.11 kg

# IfcBeam: TH-441X199X6X9.5 (8)
In: Undefined
Description: TH-441X199X6X9.5; Material: STEEL/SS400
Tekla Common - Preliminary mark: P-737; Phase: 1; Class: 5
Tekla Quantity - Weight: 530.9 kg; Volume: 0.1 m3; Gross footprint area: 0 m2; Area per tons: 32.5 m2; Net surface area: 17.5 m2; Height: 441 mm; Width: 199 mm
Pset_BeamCommon - LoadBearing: no; Reference: P-737
Name | Bottom elevation | Top elevation | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
4 x b41T | +19.062 | +19.727 | 10473 | 17.277 | 0.0661158 | 519.009
4 x b41T | +18.847 | +19.507 | 10473.1 | 17.2772 | 0.0661165 | 519.014

# IfcBeam: [-100X50X5X7.5 (43)
In: Undefined
Description: [-100X50X5X7.5; Material: STEEL/SS400
Tekla Common - Phase: 1
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 40 m2; Height: 100 mm; Width: 50 mm
Pset_BeamCommon - LoadBearing: no
Name | Bottom elevation | Top elevation | Preliminary mark = Reference | Class | Weight (kg) | Net surface area (m2) | Tekla Quantity, Length (mm) | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
2 x EP | +18.868 | +18.968 | EP-3 | 31 | 2 | 0.1 | 210 | 209.999 | 0.0785588 | 0.000246749 | 1.93698
2 x EP | +18.868 | +18.968 | EP-6 | 31 | 1.1 | 0 | 120 | 119.999 | 0.0448906 | 0.000140999 | 1.10684
23 x EP | +19.172 | +19.272 | EP-3 | 31 | 2 | 0.1 | 210 | 209.999 | 0.0785588 | 0.000246749 | 1.93698
8 x EP | +19.172 | +19.272 | EP-6 | 31 | 1.1 | 0 | 120 | 119.999 | 0.0448906 | 0.000140999 | 1.10684
8 x ST[ | +19.356 | +19.458 | ST-10 | 38 | 0.9 | 0 | 100 | 100 | 0.0374091 | 0.0001175 | 0.922375

# IfcBeam: [-125X65X6X8, b12n
In: Undefined
Description: [-125X65X6X8; Material: STEEL/SS400
Tekla Common - Bottom elevation: +3.070; Top elevation: +3.195; Preliminary mark: P-2797; Phase: 37; Class: 21
Tekla Quantity - Weight: 35.2 kg; Volume: 0 m3; Gross footprint area: 0.2 m2; Area per tons: 35.7 m2; Net surface area: 1.3 m2; Height: 125 mm; Width: 65 mm; Length: 2617.5 mm
Pset_BeamCommon - LoadBearing: no; Reference: P-2797
BaseQuantities - Length: 2617.5 mm; OuterSurfaceArea: 1.25574 m2; NetVolume: 0.00443405 m3; NetWeight: 34.8073 kg

# IfcBeam: [-150X75X6.5X10, F3
In: Undefined
Description: [-150X75X6.5X10; Material: STEEL/SS400
Tekla Common - Bottom elevation: +3.045; Top elevation: +3.195; Preliminary mark: P-2795; Phase: 37; Class: 21
Tekla Quantity - Weight: 114.9 kg; Volume: 0 m3; Gross footprint area: 0.4 m2; Area per tons: 30.4 m2; Net surface area: 3.6 m2; Height: 150 mm; Width: 75 mm; Length: 6175 mm
Pset_BeamCommon - LoadBearing: no; Reference: P-2795
BaseQuantities - Length: 6175.01 mm; OuterSurfaceArea: 3.48927 m2; NetVolume: 0.0144804 m3; NetWeight: 113.671 kg

# IfcBeam: □-500X500X22, 1C2A
In: Undefined
Description: □-500X500X22; Material: STEEL/BCR295
Tekla Common - Bottom elevation: -0.384; Top elevation: +0.046; Preliminary mark: P-524; Phase: 1; Class: 2
Tekla Quantity - Weight: 133.7 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 6 m2; Net surface area: 0.9 m2; Height: 500 mm; Width: 500 mm; Length: 430.4 mm
Pset_BeamCommon - LoadBearing: no; Reference: P-524
BaseQuantities - Length: 430.404 mm; OuterSurfaceArea: 0.803911 m2; NetVolume: 0.016612 m3; NetWeight: 130.405 kg

# IfcBeam: ○-27.2X2.3 (64)
In: Undefined
Description: ○-27.2X2.3; Material: STEEL/SS400
Tekla Common - Preliminary mark: P-1454; Phase: 1; Class: 315
Tekla Quantity - Weight: 0.1 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 60.5 m2; Net surface area: 0 m2; Height: 27.2 mm; Width: 27.2 mm; Length: 77 mm
Pset_BeamCommon - LoadBearing: no; Reference: P-1454
BaseQuantities - Length: 77 mm; OuterSurfaceArea: 0.00657973 m2; NetVolume: 0.0000132294 m3; NetWeight: 0.103851 kg
Name | Bottom elevation | Top elevation
8 x ○-27.2 | +18.288 | +18.365
8 x ○-27.2 | +18.073 | +18.150
16 x ○-27.2 | +12.893 | +12.970
16 x ○-27.2 | +8.393 | +8.470
16 x ○-27.2 | +3.993 | +4.070

# IfcColumn: FB12*50 (52)
In: Undefined
Description: FB12*50; Material: STEEL/SS400
Tekla Common - Preliminary mark: ST-20; Phase: 1; Class: 314
Tekla Quantity - Weight: 2.2 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 26.9 m2; Net surface area: 0.1 m2; Height: 50 mm; Width: 12 mm; Length: 460 mm
Pset_ColumnCommon - LoadBearing: no; Reference: ST-20
BaseQuantities - Length: 460 mm; OuterSurfaceArea: 0.05824 m2; NetVolume: 0.000276 m3; NetWeight: 2.1666 kg
Name | Bottom elevation | Top elevation
38 x FB | +19.055 | +19.515
14 x FB | +18.840 | +19.300

# IfcColumn: H-148X100X6X9 (4)
In: Undefined
Description: H-148X100X6X9; Material: STEEL/SS400
Tekla Common - Bottom elevation: +16.801; Phase: 7
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 32.4 m2; Net surface area: 1.4 m2; Height: 148 mm; Width: 100 mm
Pset_ColumnCommon - LoadBearing: no
Name | Top elevation | Preliminary mark = Reference | Class | Weight (kg) | Tekla Quantity, Length (mm) | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
P14M | +18.835 | P-2293 | 281 | 42.1 | 2034 | 2034.04 | 1.36335 | 0.00524783 | 41.1955
P14M | +18.833 | P-2333 | 26 | 42 | 2032 | 2032.04 | 1.36201 | 0.00524267 | 41.155
2 x P14M | +18.835 | P-2293 | 26 | 42.1 | 2034 | 2034.04 | 1.36335 | 0.00524783 | 41.1955

# IfcColumn: H-150X150X7X10 (12)
In: Undefined
Description: H-150X150X7X10; Material: STEEL/SS400
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 28 m2; Height: 150 mm; Width: 150 mm
Pset_ColumnCommon - LoadBearing: no
Name | Bottom elevation | Top elevation | Preliminary mark = Reference | Phase | Class | Weight (kg) | Net surface area (m2) | Tekla Quantity, Length (mm) | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
P15W | +14.385 | +15.819 | P-2731 | 1 | 291 | 44.6 | 1.3 | 1434 | 1434 | 1.25083 | 0.00560693 | 44.0144
P15W | +14.816 | +18.835 | P-2724 | 1 | 294 | 125.1 | 3.6 | 4019 | 4019 | 3.50563 | 0.015684 | 123.119 | Tekla Common - Finish: a
P15W | +14.816 | +18.835 | P-926 | 1 | 281 | 125.1 | 3.6 | 4019 | 4019 | 3.50563 | 0.0156791 | 123.081
TP15W | +18.530 | +18.941 | P-2567 | 7 | 26 | 12.7 | 0.4 | 410.8 | 410.832 | 0.358354 | 0.00160635 | 12.6099
TP15W | +18.320 | +18.835 | P-1504 | 7 | 26 | 16 | 0.4 | 515 | 515 | 0.449216 | 0.00201365 | 15.8072
TP15W | +18.320 | +19.050 | P-1506 | 7 | 26 | 22.7 | 0.7 | 730 | 730 | 0.636753 | 0.0028543 | 22.4063
TP15W | +18.320 | +18.941 | P-1505 | 7 | 26 | 19.3 | 0.7 | 620.9 | 620.869 | 0.541562 | 0.0024276 | 19.0566
P15W | +14.385 | +18.835 | P-1493 | 7 | 26 | 138.5 | 4 | 4450 | 4450 | 3.88158 | 0.0171863 | 134.913

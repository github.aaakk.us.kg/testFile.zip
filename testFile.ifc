Properties of the parts of a building model (IFC2X3), part 3 of 4

# IfcPlate: PL28*144 (2)
Tekla Quantity - Weight: 19 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 11.2 m2; Net surface area: 0.2 m2; Height: 143.5 mm; Width: 28 mm; Length: 645 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 143.5 mm; NetArea: 0.214454 m2; GrossArea: 0.0925575 m2; CrossSectionArea: 0.000784 m2; NetVolume: 0.00241684 m3; GrossVolume: 0.00260452 m3
Name | Preliminary mark = Reference
STIFFENER | K51-36
STIFFENER | K51-35

# IfcPlate: PL28*310 (7)
In: Undefined
Description: PL28*310; Material: STEEL/SN490B
Tekla Common - Phase: 1; Class: 99
Tekla Quantity - Weight: 3.9 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 23.5 m2; Net surface area: 0.1 m2; Height: 310 mm; Width: 28 mm; Length: 310 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 310 mm; NetArea: 0.091561 m2; GrossArea: 0.0961 m2; CrossSectionArea: 0.000784 m2; NetVolume: 0.000498628 m3; GrossVolume: 0.00205945 m3
Name | Bottom elevation | Top elevation | Reference
HiRing3 | +13.865 | +14.175 | 250R-1
HiRing3 | +13.865 | +14.175 | 250R+S-1
HiRing3 | +9.365 | +9.675 | 250R-1
HiRing3 | +9.420 | +9.730 | 250R-1
HiRing3 | +9.265 | +9.575 | 250R-1
2 x HiRing3 | +4.945 | +5.255 | 250R-1

# IfcPlate: PL28*370, DIAPHRAGM
In: Undefined
Description: PL28*370; Material: STEEL/SN490C
Tekla Common - Bottom elevation: +4.539; Top elevation: +5.505; Preliminary mark: K51-34; Phase: 1; Class: 314
Tekla Quantity - Weight: 78.6 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 10.1 m2; Net surface area: 0.7 m2; Height: 370 mm; Width: 28 mm; Length: 966.4 mm
Pset_PlateCommon - LoadBearing: no; Reference: K51-34
BaseQuantities - Width: 370 mm; NetArea: 0.790014 m2; GrossArea: 0.357586 m2; CrossSectionArea: 0.000784 m2; NetVolume: 0.0100124 m3; GrossVolume: 0.0100124 m3

# IfcPlate: PL28*500, 仮設ベース
In: Undefined
Description: PL28*500; Material: STEEL/SN490B
Tekla Common - Bottom elevation: -1.200; Top elevation: -1.172; Preliminary mark: K1-5; Phase: 1; Class: 328
Tekla Quantity - Weight: 46.2 kg; Volume: 0 m3; Gross footprint area: 0.2 m2; Area per tons: 10.8 m2; Net surface area: 0.4 m2; Height: 500 mm; Width: 28 mm; Length: 500 mm
Pset_PlateCommon - LoadBearing: no; Reference: K1-511
BaseQuantities - Width: 500 mm; NetArea: 0.4984 m2; GrossArea: 0.25 m2; CrossSectionArea: 0.000784 m2; NetVolume: 0.00588 m3; GrossVolume: 0.007 m3

# IfcPlate: PL32*194 (2)
In: Undefined
Description: PL32*194; Material: STEEL/SN490B
Tekla Common - Bottom elevation: -1.172; Top elevation: -0.450; Phase: 1; Class: 314
Tekla Quantity - Weight: 33.2 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 9.4 m2; Net surface area: 0.4 m2; Height: 194 mm; Width: 32 mm; Length: 722 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 194 mm; NetArea: 0.312527 m2; GrossArea: 0.140068 m2; CrossSectionArea: 0.001024 m2; NetVolume: 0.00422298 m3; GrossVolume: 0.00448218 m3
Name | Preliminary mark = Reference
PLATE | K1-53
PLATE | K1-52

# IfcPlate: PL32*405, HiRing3
In: Undefined
Description: PL32*405; Material: STEEL/SN490B
Tekla Common - Bottom elevation: +13.870; Top elevation: +14.280; Phase: 1; Class: 99
Tekla Quantity - Weight: 6.1 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 21.9 m2; Net surface area: 0.1 m2; Height: 405 mm; Width: 32 mm; Length: 405 mm
Pset_PlateCommon - LoadBearing: no; Reference: 350R-1
BaseQuantities - Width: 404.952 mm; NetArea: 0.134267 m2; GrossArea: 0.163986 m2; CrossSectionArea: 0.001024 m2; NetVolume: 0.000780994 m3; GrossVolume: 0.00415566 m3

# IfcPlate: PL32*420, PLATE
In: Undefined
Description: PL32*420; Material: STEEL/SN490B
Tekla Common - Bottom elevation: -1.172; Top elevation: -0.450; Preliminary mark: K1-51; Phase: 1; Class: 314
Tekla Quantity - Weight: 73.6 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 8.9 m2; Net surface area: 0.7 m2; Height: 420 mm; Width: 32 mm; Length: 722 mm
Pset_PlateCommon - LoadBearing: no; Reference: K1-51
BaseQuantities - Width: 420 mm; NetArea: 0.64698 m2; GrossArea: 0.30324 m2; CrossSectionArea: 0.001024 m2; NetVolume: 0.00937939 m3; GrossVolume: 0.00970368 m3

# IfcPlate: PL32*459 (5)
In: Undefined
Description: PL32*459; Material: STEEL/SN490B
Tekla Common - Phase: 1; Class: 99
Tekla Quantity - Weight: 7.7 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 20.6 m2; Net surface area: 0.2 m2; Height: 459.3 mm; Width: 32 mm; Length: 459.3 mm
Pset_PlateCommon - LoadBearing: no; Reference: 400R-1
BaseQuantities - Width: 459.275 mm; NetArea: 0.159026 m2; GrossArea: 0.210934 m2; CrossSectionArea: 0.001024 m2; NetVolume: 0.000984357 m3; GrossVolume: 0.00534538 m3
Name | Bottom elevation | Top elevation
2 x HiRing3 | +13.787 | +14.253
2 x HiRing3 | +9.287 | +9.753
HiRing3 | +9.342 | +9.807

# IfcPlate: PL32*520, DIAPHRAGM
In: Undefined
Description: PL32*520; Material: STEEL/SN490C
Tekla Common - Bottom elevation: +14.341; Top elevation: +14.373; Preliminary mark: K1-6; Phase: 1; Class: 328
Tekla Quantity - Weight: 67.9 kg; Volume: 0 m3; Gross footprint area: 0.4 m2; Area per tons: 8.9 m2; Net surface area: 0.7 m2; Height: 520 mm; Width: 32 mm; Length: 520 mm
Pset_PlateCommon - LoadBearing: no; Reference: K1-6
BaseQuantities - Width: 520 mm; NetArea: 0.60736 m2; GrossArea: 0.2704 m2; CrossSectionArea: 0.001024 m2; NetVolume: 0.0086528 m3; GrossVolume: 0.0086528 m3

# IfcPlate: PL32*570 (6)
In: Undefined
Description: PL32*570; Material: STEEL/SN490C
Tekla Common - Phase: 1; Class: 328
Tekla Quantity - Weight: 81.6 kg; Volume: 0 m3; Gross footprint area: 0.4 m2; Area per tons: 8.9 m2; Net surface area: 0.7 m2; Height: 570 mm; Width: 32 mm; Length: 570 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 570 mm; NetArea: 0.72276 m2; GrossArea: 0.3249 m2; CrossSectionArea: 0.001024 m2; NetVolume: 0.0103968 m3; GrossVolume: 0.0103968 m3
Name | Bottom elevation | Top elevation | Preliminary mark = Reference
DIAPHRAGM | +0.052 | +0.084 | K1-7
2 x DIAPHRAGM | +9.167 | +9.199 | K1-5
2 x DIAPHRAGM | +5.441 | +5.473 | K1-5
DIAPHRAGM | +4.767 | +4.799 | K1-5

# IfcPlate: PL36*520, DIAPHRAGM
In: Undefined
Description: PL36*520; Material: STEEL/SN490C
Tekla Common - Bottom elevation: +13.667; Top elevation: +13.703; Preliminary mark: K1-9; Phase: 1; Class: 328
Tekla Quantity - Weight: 76.4 kg; Volume: 0 m3; Gross footprint area: 0.4 m2; Area per tons: 8 m2; Net surface area: 0.7 m2; Height: 520 mm; Width: 36 mm; Length: 520 mm
Pset_PlateCommon - LoadBearing: no; Reference: K1-9
BaseQuantities - Width: 520 mm; NetArea: 0.61568 m2; GrossArea: 0.2704 m2; CrossSectionArea: 0.001296 m2; NetVolume: 0.0097344 m3; GrossVolume: 0.0097344 m3

# IfcPlate: PL36*570 (3)
In: Undefined
Description: PL36*570; Material: STEEL/SN490C
Tekla Common - Preliminary mark: K1-8; Phase: 1; Class: 328
Tekla Quantity - Weight: 91.8 kg; Volume: 0 m3; Gross footprint area: 0.4 m2; Area per tons: 8 m2; Net surface area: 0.7 m2; Height: 570 mm; Width: 36 mm; Length: 570 mm
Pset_PlateCommon - LoadBearing: no; Reference: K1-8
BaseQuantities - Width: 570 mm; NetArea: 0.73188 m2; GrossArea: 0.3249 m2; CrossSectionArea: 0.001296 m2; NetVolume: 0.0116964 m3; GrossVolume: 0.0116964 m3
Name | Bottom elevation | Top elevation
DIAPHRAGM | +0.398 | +0.434
DIAPHRAGM | +9.167 | +9.203
DIAPHRAGM | +4.767 | +4.803

# IfcPlate: PL40*160 (4)
In: Undefined
Description: PL40*160; Material: STEEL/SN490B
Tekla Common - Bottom elevation: -0.900; Top elevation: -0.456; Preliminary mark: K1-80; Phase: 1; Class: 314
Tekla Quantity - Weight: 21.6 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 8.6 m2; Net surface area: 0.2 m2; Height: 160 mm; Width: 40 mm; Length: 444 mm
Pset_PlateCommon - LoadBearing: no; Reference: K1-80
BaseQuantities - Width: 160 mm; NetArea: 0.186211 m2; GrossArea: 0.07104 m2; CrossSectionArea: 0.0016 m2; NetVolume: 0.00275197 m3; GrossVolume: 0.00288 m3

# IfcPlate: PL40*520 (4)
In: Undefined
Description: PL40*520; Material: STEEL/SN490C
Tekla Common - Preliminary mark: K1-10; Phase: 1; Class: 328
Tekla Quantity - Weight: 84.9 kg; Volume: 0 m3; Gross footprint area: 0.4 m2; Area per tons: 7.3 m2; Net surface area: 0.7 m2; Height: 520 mm; Width: 40 mm; Length: 520 mm
Pset_PlateCommon - LoadBearing: no; Reference: K1-10
BaseQuantities - Width: 520 mm; NetArea: 0.624 m2; GrossArea: 0.2704 m2; CrossSectionArea: 0.0016 m2; NetVolume: 0.010816 m3; GrossVolume: 0.010816 m3
Name | Bottom elevation | Top elevation
2 x DIAPHRAGM | +13.667 | +13.707
2 x DIAPHRAGM | +14.333 | +14.373

# IfcPlate: PL40*570 (5)
In: Undefined
Description: PL40*570; Material: STEEL/SN490C
Tekla Common - Preliminary mark: K1-11; Phase: 1; Class: 328
Tekla Quantity - Weight: 102 kg; Volume: 0 m3; Gross footprint area: 0.4 m2; Area per tons: 7.3 m2; Net surface area: 0.7 m2; Height: 570 mm; Width: 40 mm; Length: 570 mm
Pset_PlateCommon - LoadBearing: no; Reference: K1-11
BaseQuantities - Width: 570 mm; NetArea: 0.741 m2; GrossArea: 0.3249 m2; CrossSectionArea: 0.0016 m2; NetVolume: 0.012996 m3; GrossVolume: 0.012996 m3
Name | Bottom elevation | Top elevation
DIAPHRAGM | +9.167 | +9.207
2 x DIAPHRAGM | +4.767 | +4.807
2 x DIAPHRAGM | +5.433 | +5.473

# IfcPlate: PL44*710 (3)
In: Undefined
Description: PL44*710; Material: STEEL/SN490B
Tekla Common - Bottom elevation: -0.450; Top elevation: -0.406; Phase: 1; Class: 99
Tekla Quantity - Weight: 169.3 kg; Volume: 0 m3; Gross footprint area: 0.4 m2; Area per tons: 6.8 m2; Net surface area: 1.1 m2; Height: 710 mm; Width: 44 mm; Length: 710 mm
Pset_PlateCommon - LoadBearing: no; Reference: EB500-8-36-2
BaseQuantities - Width: 710 mm; NetArea: 1.14381 m2; GrossArea: 0.5041 m2; CrossSectionArea: 0.001936 m2; NetVolume: 0.021562 m3; GrossVolume: 0.0221804 m3

# IfcPlate: PL45*520 (2)
In: Undefined
Description: PL45*520; Material: STEEL/TMCP325C
Tekla Common - Preliminary mark: K1-12; Phase: 1; Class: 328
Tekla Quantity - Weight: 95.5 kg; Volume: 0 m3; Gross footprint area: 0.4 m2; Area per tons: 6.6 m2; Net surface area: 0.7 m2; Height: 520 mm; Width: 45 mm; Length: 520 mm
Pset_PlateCommon - LoadBearing: no; Reference: K1-12
BaseQuantities - Width: 520 mm; NetArea: 0.6344 m2; GrossArea: 0.2704 m2; CrossSectionArea: 0.002025 m2; NetVolume: 0.012168 m3; GrossVolume: 0.012168 m3
Name | Bottom elevation | Top elevation
DIAPHRAGM | +13.667 | +13.712
DIAPHRAGM | +14.328 | +14.373

# IfcPlate: PL48*550 (4)
In: Undefined
Description: PL48*550; Material: STEEL/SN490C
Tekla Common - Bottom elevation: +9.825; Top elevation: +9.873; Phase: 1; Class: 329
Tekla Quantity - Weight: 114 kg; Volume: 0 m3; Gross footprint area: 0.4 m2; Area per tons: 6.2 m2; Net surface area: 0.7 m2; Height: 550 mm; Width: 48 mm; Length: 550 mm
Pset_PlateCommon - LoadBearing: no; Reference: SD-500-50-2
BaseQuantities - Width: 550 mm; NetArea: 0.7106 m2; GrossArea: 0.3025 m2; CrossSectionArea: 0.002304 m2; NetVolume: 0.01452 m3; GrossVolume: 0.01452 m3

# IfcPlate: PL6*100 (15)
In: Undefined
Description: PL6*100; Material: STEEL/SS400
Tekla Common - Phase: 1
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Net surface area: 0 m2; Height: 100 mm; Width: 6 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 100 mm; CrossSectionArea: 0.000036 m2
Name | Bottom elevation | Top elevation | Preliminary mark = Reference | Class | Weight (kg) | Area per tons (m2) | Length (mm) | NetArea (m2) | GrossArea (m2) | NetVolume (m3) = GrossVolume (m3)
4 x GUSSET | +14.270 | +14.370 | KG-14 | 282 | 0.9 | 46.2 | 221.5 | 0.0464139 | 0.02215 | 0.000127884
11 x ST | +18.868 | +18.874 | ST-15 | 316 | 0.4 | 47.6 | 100 | 0.0224 | 0.01 | 0.00006

# IfcPlate: PL6*128 (3)
In: Undefined
Description: PL6*128; Material: STEEL/SS400
Tekla Common - Bottom elevation: +18.373; Top elevation: +18.520; Preliminary mark: KG-171; Phase: 7; Class: 72
Tekla Quantity - Weight: 0.9 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 46.1 m2; Net surface area: 0 m2; Height: 128 mm; Width: 6 mm; Length: 146.9 mm
Pset_PlateCommon - LoadBearing: no; Reference: KG-171
BaseQuantities - Width: 128 mm; NetArea: 0.0407169 m2; GrossArea: 0.0188013 m2; CrossSectionArea: 0.000036 m2; NetVolume: 0.000112424 m3; GrossVolume: 0.000112424 m3

# IfcPlate: PL6*135 (5)
In: Undefined
Description: PL6*135; Material: STEEL/SS400
Tekla Common - Phase: 1; Class: 314
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Net surface area: 0.1 m2; Height: 134.5 mm; Width: 6 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 134.5 mm; CrossSectionArea: 0.000036 m2
Name | Bottom elevation | Top elevation | Preliminary mark = Reference | Weight (kg) | Area per tons (m2) | Length (mm) | NetArea (m2) | GrossArea (m2) | NetVolume (m3) = GrossVolume (m3)
STIFFENER | +18.977 | +19.197 | K52-149 | 1.4 | 45.5 | 220 | 0.0632193 | 0.02959 | 0.000177033
STIFFENER | +19.138 | +19.540 | K62-206 | 2.5 | 45 | 402 | 0.114146 | 0.0540686 | 0.000323398
STIFFENER | +19.032 | +19.434 | K62-206 | 2.5 | 45 | 402 | 0.114146 | 0.0540686 | 0.000323398
STIFFENER | +18.977 | +19.379 | K62-206 | 2.5 | 45 | 402 | 0.114146 | 0.0540686 | 0.000323398
STIFFENER | +18.921 | +19.323 | K62-206 | 2.5 | 45 | 402 | 0.114146 | 0.0540686 | 0.000323398

# IfcPlate: PL6*140, GUSSET
In: Undefined
Description: PL6*140; Material: STEEL/SS400
Tekla Common - Bottom elevation: +18.879; Top elevation: +19.019; Preliminary mark: K2-21; Phase: 1; Class: 314
Tekla Quantity - Weight: 1.6 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 45.3 m2; Net surface area: 0.1 m2; Height: 140 mm; Width: 6 mm; Length: 245 mm
Pset_PlateCommon - LoadBearing: no; Reference: K2-21
BaseQuantities - Width: 140 mm; NetArea: 0.07322 m2; GrossArea: 0.0343 m2; CrossSectionArea: 0.000036 m2; NetVolume: 0.0002058 m3; GrossVolume: 0.0002058 m3

# IfcPlate: PL6*145, GUSSET
In: Undefined
Description: PL6*145; Material: STEEL/SS400
Tekla Common - Bottom elevation: +19.208; Top elevation: +19.379; Preliminary mark: K52-173; Phase: 1; Class: 314
Tekla Quantity - Weight: 1.1 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 45.6 m2; Net surface area: 0.1 m2; Height: 144.5 mm; Width: 6 mm; Length: 170 mm
Pset_PlateCommon - LoadBearing: no; Reference: K52-173
BaseQuantities - Width: 144.5 mm; NetArea: 0.052419 m2; GrossArea: 0.024565 m2; CrossSectionArea: 0.000036 m2; NetVolume: 0.000146283 m3; GrossVolume: 0.000146283 m3

# IfcPlate: PL6*162 (2)
In: Undefined
Description: PL6*162; Material: STEEL/SS400
Tekla Common - Bottom elevation: +18.864; Top elevation: +19.038; Preliminary mark: K62-259; Phase: 1; Class: 314
Tekla Quantity - Weight: 1.1 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 45.9 m2; Net surface area: 0.1 m2; Height: 162 mm; Width: 6 mm; Length: 174 mm
Pset_PlateCommon - LoadBearing: no; Reference: K62-259
BaseQuantities - Width: 162 mm; NetArea: 0.0515614 m2; GrossArea: 0.028188 m2; CrossSectionArea: 0.000036 m2; NetVolume: 0.000143194 m3; GrossVolume: 0.000143194 m3

# IfcPlate: PL6*170, GUSSET
In: Undefined
Description: PL6*170; Material: STEEL/SS400
Tekla Common - Bottom elevation: +3.266; Top elevation: +3.272; Preliminary mark: F-22; Phase: 37; Class: 314
Tekla Quantity - Weight: 0.9 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 46.7 m2; Net surface area: 0 m2; Height: 170 mm; Width: 6 mm; Length: 140 mm
Pset_PlateCommon - LoadBearing: no; Reference: F-22
BaseQuantities - Width: 170 mm; NetArea: 0.0383609 m2; GrossArea: 0.0238 m2; CrossSectionArea: 0.000036 m2; NetVolume: 0.00010455 m3; GrossVolume: 0.00010455 m3

# IfcPlate: PL6*220 (2)
In: Undefined
Description: PL6*220; Material: STEEL/SS400
Tekla Common - Phase: 37; Class: 314
Tekla Quantity - Volume: 0 m3; Area per tons: 43.7 m2; Height: 220 mm; Width: 6 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 220 mm; CrossSectionArea: 0.000036 m2
Name | Bottom elevation | Top elevation | Preliminary mark = Reference | Weight (kg) | Gross footprint area (m2) | Net surface area (m2) | Length (mm) | NetArea (m2) | GrossArea (m2) | NetVolume (m3) = GrossVolume (m3)
PLATE | +3.219 | +3.225 | F-15 | 64.2 | 1.4 | 2.8 | 6195 | 2.80278 | 1.3629 | 0.0081774
PLATE | +3.325 | +3.331 | F-14 | 20.7 | 0.4 | 0.9 | 1999.5 | 0.906413 | 0.43989 | 0.00263934

# IfcPlate: PL6*235 (7)
In: Undefined
Description: PL6*235; Material: STEEL/SS400
Tekla Common - Phase: 1; Class: 314
Tekla Quantity - Weight: 3.2 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 44.8 m2; Net surface area: 0.1 m2; Height: 234.5 mm; Width: 6 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 234.5 mm; CrossSectionArea: 0.000036 m2
Name | Bottom elevation | Top elevation | Preliminary mark = Reference | Length (mm) | NetArea (m2) | GrossArea (m2) | NetVolume (m3) = GrossVolume (m3)
GUSSET | +19.138 | +19.540 | K62-213 | 402 | 0.143344 | 0.0942684 | 0.000407604
GUSSET | +19.136 | +19.538 | K52-156 | 402 | 0.143345 | 0.094269 | 0.000407607
GUSSET | +19.033 | +19.435 | K52-156 | 402 | 0.143345 | 0.094269 | 0.000407607
GUSSET | +18.920 | +19.322 | K52-156 | 402 | 0.143345 | 0.094269 | 0.000407607
GUSSET | +19.032 | +19.435 | K62-214 | 403.2 | 0.143359 | 0.0945466 | 0.000407604
GUSSET | +18.977 | +19.379 | K62-219 | 402 | 0.143344 | 0.0942684 | 0.000407604
GUSSET | +18.921 | +19.323 | K62-213 | 402 | 0.143344 | 0.0942684 | 0.000407604

# IfcPlate: PL6*345 (4)
In: Undefined
Description: PL6*345; Material: STEEL/SS400
Tekla Common - Bottom elevation: +4.779; Top elevation: +5.124; Preliminary mark: K61-167; Phase: 1; Class: 314
Tekla Quantity - Weight: 17.1 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 43.4 m2; Net surface area: 0.7 m2; Height: 345 mm; Width: 6 mm; Length: 1050 mm
Pset_PlateCommon - LoadBearing: no; Reference: K61-167
BaseQuantities - Width: 345 mm; NetArea: 0.74124 m2; GrossArea: 0.36225 m2; CrossSectionArea: 0.000036 m2; NetVolume: 0.0021735 m3; GrossVolume: 0.0021735 m3

# IfcPlate: PL6*465 (3)
In: Undefined
Description: PL6*465; Material: STEEL/SS400
Tekla Common - Bottom elevation: +18.869; Top elevation: +19.271; Phase: 1; Class: 314
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 44.6 m2; Net surface area: 0.2 m2; Height: 464.5 mm; Width: 6 mm; Length: 402 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 464.5 mm; GrossArea: 0.186729 m2; CrossSectionArea: 0.000036 m2
Name | Preliminary mark = Reference | Weight (kg) | NetArea (m2) | NetVolume (m3) = GrossVolume (m3)
GUSSET | K52-201 | 4.8 | 0.215745 | 0.000616527
2 x GUSSET | K52-200 | 4.6 | 0.210505 | 0.000600807

# IfcPlate: PL6*47 (20)
In: Undefined
Description: PL6*47; Material: STEEL/SS400
Tekla Common - Phase: 1; Class: 321
Tekla Quantity - Weight: 0.4 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 49.2 m2; Net surface area: 0 m2; Height: 47.3 mm; Width: 6 mm; Length: 182 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 47.25 mm; NetArea: 0.0196797 m2; GrossArea: 0.0085995 m2; CrossSectionArea: 0.000036 m2; NetVolume: 0.000050997 m3; GrossVolume: 0.000050997 m3
Name | Bottom elevation | Top elevation | Preliminary mark = Reference
4 x STIFFENER | +16.809 | +16.991 | M-3001
4 x STIFFENER | +16.809 | +16.991 | M-10
4 x STIFFENER | +14.959 | +15.141 | M-3001
4 x STIFFENER | +14.959 | +15.141 | M-10
2 x STIFFENER | +18.858 | +19.040 | M-3001
2 x STIFFENER | +18.858 | +19.040 | M-10

# IfcPlate: PL6*48 (6)
In: Undefined
Description: PL6*48; Material: STEEL/SS400
Tekla Common - Bottom elevation: +15.666; Top elevation: +15.794; Phase: 1; Class: 321
Tekla Quantity - Weight: 0.4 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 49.7 m2; Net surface area: 0 m2; Width: 6 mm; Length: 128 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - CrossSectionArea: 0.000036 m2
Name | Preliminary mark = Reference | Height (mm) | Width (mm) | NetArea (m2) | GrossArea (m2) | NetVolume (m3) = GrossVolume (m3)
3 x STIFFENER | M-3008 | 47.7 | 47.7434 | 0.0140609 | 0.00611116 | 0.0000360669
3 x STIFFENER | M-11 | 47.8 | 47.7566 | 0.0140645 | 0.00611285 | 0.0000360771

# IfcPlate: PL6*50 (9)
In: Undefined
Description: PL6*50; Material: STEEL/SS400
Tekla Quantity - Weight: 0.2 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 50.1 m2; Net surface area: 0 m2; Height: 50 mm; Width: 6 mm; Length: 100 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 50 mm; NetArea: 0.0118 m2; GrossArea: 0.005 m2; CrossSectionArea: 0.000036 m2; NetVolume: 0.00003 m3; GrossVolume: 0.00003 m3
Name | Bottom elevation | Top elevation | Preliminary mark | Phase | Class | Reference
3 x PLATE | +3.079 | +3.085 | F-20 | 37 | 314 | F-20
2 x PLATE | +3.064 | +3.070 | F-20 | 37 | 314 | F-20
2 x PLATE | +3.195 | +3.201 | F-20 | 37 | 314 | F-20
HP | +18.650 | +18.750 | HP-1 | 1 | 87 | HP-1
HP | -0.406 | -0.400 |  | 1 | 87 | HP-1

# IfcPlate: PL6*560 (2)
In: Undefined
Description: PL6*560; Material: STEEL/SS400
Tekla Common - Bottom elevation: -0.120; Top elevation: -0.114; Preliminary mark: K1-82; Phase: 1; Class: 314
Tekla Quantity - Weight: 2.9 kg; Volume: 0 m3; Gross footprint area: 0.1 m2; Area per tons: 50.8 m2; Net surface area: 0.2 m2; Height: 560 mm; Width: 6 mm; Length: 560 mm
Pset_PlateCommon - LoadBearing: no; Reference: K1-82
BaseQuantities - Width: 560 mm; NetArea: 0.152414 m2; GrossArea: 0.3136 m2; CrossSectionArea: 0.000036 m2; NetVolume: 0.000382281 m3; GrossVolume: 0.0018816 m3

# IfcPlate: PL6*62 (2)
In: Undefined
Description: PL6*62; Material: STEEL/SS400
Tekla Common - Bottom elevation: +18.864; Top elevation: +19.038; Preliminary mark: K62-260; Phase: 1; Class: 314
Tekla Quantity - Weight: 0.4 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 48.3 m2; Net surface area: 0 m2; Height: 62 mm; Width: 6 mm; Length: 174 mm
Pset_PlateCommon - LoadBearing: no; Reference: K62-260
BaseQuantities - Width: 62 mm; NetArea: 0.0223628 m2; GrossArea: 0.010788 m2; CrossSectionArea: 0.000036 m2; NetVolume: 0.0000589877 m3; GrossVolume: 0.0000589877 m3

# IfcPlate: PL6*65, PLATE
In: Undefined
Description: PL6*65; Material: STEEL/SS400
Tekla Common - Bottom elevation: +3.201; Top elevation: +3.266; Phase: 37; Class: 314
Tekla Quantity - Weight: 0.4 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 48.7 m2; Net surface area: 0 m2; Height: 65 mm; Width: 6 mm; Length: 150 mm
Pset_PlateCommon - LoadBearing: no; Reference: P-2847
BaseQuantities - Width: 65 mm; NetArea: 0.0189365 m2; GrossArea: 0.00975 m2; CrossSectionArea: 0.000036 m2; NetVolume: 0.000049575 m3; GrossVolume: 0.000049575 m3

# IfcPlate: PL6*72 (8)
In: Undefined
Description: PL6*72; Material: STEEL/SS400
Tekla Common - Phase: 1
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Net surface area: 0 m2; Width: 6 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - CrossSectionArea: 0.000036 m2
Name | Bottom elevation | Top elevation | Preliminary mark = Reference | Class | Weight (kg) | Area per tons (m2) | Height (mm) | Length (mm) | Width (mm) | NetArea (m2) | GrossArea (m2) | NetVolume (m3) = GrossVolume (m3)
2 x STIFFENER | +18.080 | +18.086 | KG-61 | 292 | 0.4 | 47.9 | 71.5 | 128 | 71.5 | 0.0204277 | 0.009152 | 0.000054312
4 x STIFFENER | +18.080 | +18.086 | M-13 | 321 | 0.4 | 47.9 | 71.5 | 128 | 71.5 | 0.0204277 | 0.009152 | 0.000054312
STIFFENER | +18.864 | +19.038 | M-3009 | 321 | 0.6 | 47.4 | 72 | 174 | 72 | 0.0277377 | 0.012528 | 0.000074568
STIFFENER | +18.864 | +19.038 | M-12 | 321 | 0.6 | 47.4 | 72 | 174 | 72.0003 | 0.0277378 | 0.0125281 | 0.0000745683

# IfcPlate: PL6*80, GUSSET
In: Undefined
Description: PL6*80; Material: STEEL/SS400
Tekla Common - Bottom elevation: +3.093; Top elevation: +3.173; Preliminary mark: F-10; Phase: 37; Class: 314
Tekla Quantity - Weight: 1.2 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 46.5 m2; Net surface area: 0.1 m2; Height: 80 mm; Width: 6 mm; Length: 310 mm
Pset_PlateCommon - LoadBearing: no; Reference: F-10
BaseQuantities - Width: 80 mm; NetArea: 0.0542797 m2; GrossArea: 0.0247999 m2; CrossSectionArea: 0.000036 m2; NetVolume: 0.000148799 m3; GrossVolume: 0.000148799 m3

# IfcPlate: PL6*90 (38)
In: Undefined
Description: PL6*90; Material: STEEL/SS400
Tekla Common - Phase: 1
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Height: 90 mm; Width: 6 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 90 mm; CrossSectionArea: 0.000036 m2
Name | Bottom elevation | Top elevation | Preliminary mark = Reference | Class | Weight (kg) | Area per tons (m2) | Net surface area (m2) | Length (mm) | NetArea (m2) | GrossArea (m2) | NetVolume (m3) = GrossVolume (m3)
2 x STIFFENER | +18.086 | +18.176 | KG-62 | 292 | 0.4 | 47.3 | 0 | 128 | 0.025656 | 0.01152 | 0.00006912
4 x STIFFENER | +18.086 | +18.176 | M-9 | 321 | 0.4 | 47.3 | 0 | 128 | 0.025656 | 0.01152 | 0.00006912
2 x STIFFENER | +18.864 | +19.038 | M-3005 | 321 | 0.6 | 46.8 | 0 | 174 | 0.034488 | 0.01566 | 0.00009396
8 x STIFFENER | +16.809 | +16.991 | M-3003 | 321 | 0.9 | 46.7 | 0 | 182 | 0.036024 | 0.01638 | 0.00009828
8 x STIFFENER | +14.959 | +15.141 | M-3003 | 321 | 0.9 | 46.7 | 0 | 182 | 0.036024 | 0.01638 | 0.00009828
6 x STIFFENER | +15.666 | +15.794 | M-3004 | 321 | 0.4 | 47.3 | 0 | 128 | 0.025656 | 0.01152 | 0.00006912
4 x STIFFENER | +18.858 | +19.040 | M-3003 | 321 | 0.9 | 46.7 | 0 | 182 | 0.036024 | 0.01638 | 0.00009828
PLATE | +19.002 | +19.008 | K52-234 | 314 | 1.2 | 46.2 | 0.1 | 274.5 | 0.0537839 | 0.024705 | 0.00014823
2 x PLATE | +19.003 | +19.009 | K52-234 | 314 | 1.2 | 46.2 | 0.1 | 274.5 | 0.0537839 | 0.024705 | 0.00014823
PLATE | +19.003 | +19.009 | K52-235 | 314 | 0.6 | 47.1 | 0 | 140 | 0.02796 | 0.0126 | 0.0000755999

# IfcPlate: PL6*95 (4)
In: Undefined
Description: PL6*95; Material: STEEL/SS400
Tekla Common - Bottom elevation: +16.830; Top elevation: +16.970; Phase: 7
Tekla Quantity - Weight: 0.6 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 47 m2; Net surface area: 0 m2; Height: 95 mm; Width: 6 mm; Length: 140 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 95 mm; NetArea: 0.02942 m2; GrossArea: 0.0133 m2; CrossSectionArea: 0.000036 m2; NetVolume: 0.0000798 m3; GrossVolume: 0.0000798 m3
Name | Class | Reference
GUSSET | 282 | K72-39 | Tekla Common - Preliminary mark: K72-39
3 x GUSSET | 314 | K82-48

# IfcPlate: PL60*430 (2)
In: Undefined
Description: PL60*430; Material: STEEL/SN490B
Tekla Common - Bottom elevation: +9.357; Top elevation: +9.793; Phase: 1; Class: 99
Tekla Quantity - Weight: 18.5 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 12.9 m2; Net surface area: 0.2 m2; Height: 429.6 mm; Width: 60 mm; Length: 429.6 mm
Pset_PlateCommon - LoadBearing: no; Reference: 350B-1
BaseQuantities - Width: 429.644 mm; NetArea: 0.239288 m2; GrossArea: 0.184594 m2; CrossSectionArea: 0.0036 m2; NetVolume: 0.00236215 m3; GrossVolume: 0.00877106 m3

# IfcPlate: PL9*100 (30)
In: Undefined
Description: PL9*100; Material: STEEL/SS400
Tekla Common - Phase: 1; Class: 314
Tekla Quantity - Weight: 0.6 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 33.4 m2; Net surface area: 0 m2; Height: 100 mm; Width: 9 mm; Length: 100 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 100 mm; NetArea: 0.0236 m2; GrossArea: 0.01 m2; CrossSectionArea: 0.000081 m2; NetVolume: 0.00009 m3; GrossVolume: 0.00009 m3
Name | Bottom elevation | Top elevation | Preliminary mark = Reference
GUSSET | +18.905 | +19.005 | K62-38
GUSSET | +18.924 | +19.024 | K62-38
GUSSET | +18.943 | +19.043 | K62-38
GUSSET | +18.961 | +19.062 | K62-38
GUSSET | +18.980 | +19.080 | K62-38
GUSSET | +18.999 | +19.099 | K62-38
GUSSET | +19.018 | +19.118 | K62-38
GUSSET | +19.037 | +19.137 | K62-38
GUSSET | +19.056 | +19.156 | K62-38
GUSSET | +19.074 | +19.175 | K62-38
GUSSET | +19.093 | +19.193 | K62-38
GUSSET | +19.112 | +19.212 | K62-38
GUSSET | +19.120 | +19.220 | K62-38
GUSSET | +19.139 | +19.240 | K62-38
GUSSET | +19.159 | +19.259 | K62-38
GUSSET | +18.999 | +19.099 | K52-59
GUSSET | +18.980 | +19.080 | K52-59
GUSSET | +18.961 | +19.062 | K52-59
GUSSET | +18.943 | +19.043 | K52-59
GUSSET | +18.924 | +19.024 | K52-59
GUSSET | +18.905 | +19.005 | K52-59
GUSSET | +19.018 | +19.118 | K52-59
GUSSET | +19.037 | +19.137 | K52-59
GUSSET | +19.056 | +19.156 | K52-59
GUSSET | +19.074 | +19.175 | K52-59
GUSSET | +19.093 | +19.193 | K52-59
GUSSET | +19.112 | +19.212 | K52-59
GUSSET | +19.120 | +19.220 | K52-59
GUSSET | +19.139 | +19.240 | K52-59
GUSSET | +19.159 | +19.259 | K52-59

# IfcPlate: PL9*106 (2)
In: Undefined
Description: PL9*106; Material: STEEL/SS400
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Net surface area: 0 m2; Height: 106 mm; Width: 9 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 106 mm; CrossSectionArea: 0.000081 m2
Name | Bottom elevation | Top elevation | Preliminary mark = Reference | Phase | Class | Weight (kg) | Area per tons (m2) | Length (mm) | NetArea (m2) | GrossArea (m2) | NetVolume (m3) = GrossVolume (m3)
GUSSET | +15.522 | +15.628 | KG-43 | 7 | 5555 | 1.2 | 33.2 | 221.5 | 0.0391461 | 0.0234791 | 0.000149998
GUSSET | +19.442 | +19.549 | K62-14 | 1 | 314 | 1.1 | 33.7 | 200 | 0.0387857 | 0.0212 | 0.000146457

# IfcPlate: PL9*110 (10)
In: Undefined
Description: PL9*110; Material: STEEL/SS400
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Net surface area: 0 m2; Width: 9 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - CrossSectionArea: 0.000081 m2
Name | Bottom elevation | Top elevation | Preliminary mark | Phase | Class | Weight (kg) | Area per tons (m2) | Height (mm) | Length (mm) | Reference | Width (mm) | NetArea (m2) | GrossArea (m2) | NetVolume (m3) = GrossVolume (m3)
2 x GUSSET | +3.077 | +3.188 | F-3 | 37 | 314 | 1.2 | 32.6 | 110.4 | 209 | F-3 | 110.412 | 0.0414361 | 0.0230761 | 0.000161737
2 x GUSSET | +15.028 | +15.037 | K72-34 | 1 | 282 | 1.4 | 32.1 | 110 | 175 | K72-34 | 110 | 0.04363 | 0.01925 | 0.00017325
GUSSET | +18.358 | +18.367 |  | 7 | 314 | 1.2 | 32.4 | 110 | 155 | K82-10 | 110 | 0.03887 | 0.01705 | 0.00015345
5 x GUSSET | +15.028 | +15.037 | K72-30 | 1 | 314 | 1.4 | 32.1 | 110 | 175 | K72-30 | 110 | 0.04363 | 0.01925 | 0.00017325

# IfcPlate: PL9*126 (3)
In: Undefined
Description: PL9*126; Material: STEEL/SS400
Tekla Common - Phase: 1; Class: 520
Tekla Quantity - Weight: 0.6 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 34.3 m2; Net surface area: 0 m2; Height: 125.7 mm; Width: 9 mm; Length: 113.3 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 125.652 mm; NetArea: 0.0229474 m2; GrossArea: 0.0142406 m2; CrossSectionArea: 0.000081 m2; NetVolume: 0.0000851599 m3; GrossVolume: 0.0000851599 m3
Name | Bottom elevation | Top elevation | Preliminary mark = Reference
K4 | +19.290 | +19.390 | P-2162
2 x K4 | +14.370 | +14.470 | P-2465

# IfcPlate: PL9*128 (23)
In: Undefined
Description: PL9*128; Material: STEEL/SS400
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Net surface area: 0 m2; Height: 128 mm; Width: 9 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 128 mm; CrossSectionArea: 0.000081 m2
Name | Bottom elevation | Top elevation | Phase | Class | Weight (kg) | Area per tons (m2) | Length (mm) | Reference | NetArea (m2) | GrossArea (m2) | NetVolume (m3) = GrossVolume (m3)
GUSSET | +15.666 | +15.794 | 7 | 314 | 1.4 | 32.6 | 221.5 | KG-70 | 0.0462671 | 0.028352 | 0.00018096 | Tekla Common - Preliminary mark: KG-70
GUSSET | +15.666 | +15.794 | 1 | 314 | 1.2 | 33 | 197 | K72-21 | 0.0395027 | 0.025216 | 0.000152623
2 x GUSSET | +15.666 | +15.794 | 1 | 282 | 1.2 | 33 | 197 | K72-35 | 0.0395027 | 0.025216 | 0.000152623 | Tekla Common - Preliminary mark: K72-35
2 x GUSSET | +16.888 | +16.897 | 7 | 282 | 1.2 | 32.9 | 197 | K72-38 | 0.0407245 | 0.0252161 | 0.000157671 | Tekla Common - Preliminary mark: K72-38
6 x GUSSET | +18.358 | +18.367 | 7 | 314 | 1.4 | 32.5 | 221.5 | K82-20 | 0.0474374 | 0.028352 | 0.000185894
GUSSET | +16.888 | +16.897 | 7 | 314 | 1.4 | 32.5 | 221.5 | K82-19 | 0.0474375 | 0.028352 | 0.000185895
6 x GUSSET | +16.888 | +16.897 | 7 | 314 | 1.2 | 32.9 | 197 | K82-18 | 0.0407245 | 0.0252161 | 0.000157671
4 x GUSSET | +15.666 | +15.794 | 1 | 314 | 1.2 | 33 | 197 | K72-21 | 0.0395027 | 0.025216 | 0.000152623 | Tekla Common - Preliminary mark: K72-21

# IfcPlate: PL9*130 (2)
In: Undefined
Description: PL9*130; Material: STEEL/SS400
Tekla Common - Bottom elevation: +15.665; Top elevation: +15.795; Preliminary mark: KG-64; Phase: 1; Class: 290
Tekla Quantity - Weight: 1.4 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 32.6 m2; Net surface area: 0 m2; Height: 130 mm; Width: 9 mm; Length: 221.5 mm
Pset_PlateCommon - LoadBearing: no; Reference: KG-64
BaseQuantities - Width: 130 mm; NetArea: 0.0464977 m2; GrossArea: 0.028795 m2; CrossSectionArea: 0.000081 m2; NetVolume: 0.000181954 m3; GrossVolume: 0.000181954 m3

# IfcPlate: PL9*132 (4)
In: Undefined
Description: PL9*132; Material: STEEL/SS400
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Height: 132 mm; Width: 9 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 132 mm; CrossSectionArea: 0.000081 m2
Name | Bottom elevation | Top elevation | Phase | Class | Weight (kg) | Area per tons (m2) | Net surface area (m2) | Length (mm) | Reference | NetArea (m2) | GrossArea (m2) | NetVolume (m3) | GrossVolume (m3)
2 x GUSSET | +13.707 | +14.333 | 1 | 5555 | 5.8 | 30.6 | 0.2 | 626 | KG-53 | 0.1783 | 0.082632 | 0.000741663 | 0.000741663 | Tekla Common - Preliminary mark: KG-53
GUSSET | +15.424 | +15.556 | 7 | 314 | 0.6 | 34.3 | 0 | 61.5 | K82-9 | 0.0195065 | 0.00811795 | 0.0000724855 | 0.000188108
GUSSET | +15.424 | +15.556 | 7 | 314 | 0.6 | 34.3 | 0 | 61.5 | K82-9 | 0.0195065 | 0.00811793 | 0.0000724852 | 0.000188108

# IfcPlate: PL9*134 (2)
In: Undefined
Description: PL9*134; Material: STEEL/SS400
Tekla Common - Phase: 1; Class: 314
Tekla Quantity - Weight: 6.1 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 30.6 m2; Net surface area: 0.2 m2; Height: 133.5 mm; Width: 9 mm; Length: 650 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 133.5 mm; NetArea: 0.186815 m2; GrossArea: 0.086775 m2; CrossSectionArea: 0.000081 m2; NetVolume: 0.000778059 m3; GrossVolume: 0.000778059 m3
Name | Bottom elevation | Top elevation | Preliminary mark = Reference
STIFFENER | +4.799 | +5.449 | K51-24
STIFFENER | +13.695 | +14.345 | K52-39

# IfcPlate: PL9*137 (8)
In: Undefined
Description: PL9*137; Material: STEEL/SS400
Tekla Common - Bottom elevation: +18.858; Top elevation: +19.040; Preliminary mark: K62-232; Phase: 1; Class: 314
Tekla Quantity - Weight: 1.4 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 32.2 m2; Net surface area: 0 m2; Height: 137.3 mm; Width: 9 mm; Length: 182 mm
Pset_PlateCommon - LoadBearing: no; Reference: K62-232
BaseQuantities - Width: 137.25 mm; NetArea: 0.0458862 m2; GrossArea: 0.0249795 m2; CrossSectionArea: 0.000081 m2; NetVolume: 0.000181815 m3; GrossVolume: 0.000181815 m3

# IfcPlate: PL9*142 (2)
In: Undefined
Description: PL9*142; Material: STEEL/SS400
Tekla Common - Bottom elevation: +13.707; Top elevation: +14.333; Preliminary mark: K52-48; Phase: 1; Class: 314
Tekla Quantity - Weight: 6.4 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 30.4 m2; Net surface area: 0.2 m2; Height: 142 mm; Width: 9 mm; Length: 626 mm
Pset_PlateCommon - LoadBearing: no; Reference: K52-48
BaseQuantities - Width: 142 mm; NetArea: 0.190465 m2; GrossArea: 0.088892 m2; CrossSectionArea: 0.000081 m2; NetVolume: 0.000796212 m3; GrossVolume: 0.000796212 m3

# IfcPlate: PL9*143 (6)
In: Undefined
Description: PL9*143; Material: STEEL/SS400
Tekla Common - Bottom elevation: +13.703; Top elevation: +14.337; Preliminary mark: K52-46; Phase: 1; Class: 314
Tekla Quantity - Weight: 6.4 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 30.4 m2; Net surface area: 0.2 m2; Height: 143 mm; Width: 9 mm; Length: 634 mm
Pset_PlateCommon - LoadBearing: no; Reference: K52-46
BaseQuantities - Width: 143 mm; NetArea: 0.194167 m2; GrossArea: 0.090662 m2; CrossSectionArea: 0.000081 m2; NetVolume: 0.000812142 m3; GrossVolume: 0.000812142 m3

# IfcPlate: PL9*144 (2)
In: Undefined
Description: PL9*144; Material: STEEL/SN490B
Tekla Common - Bottom elevation: +13.695; Top elevation: +14.345; Preliminary mark: K52-44; Phase: 1; Class: 314
Tekla Quantity - Weight: 6.7 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 30.4 m2; Net surface area: 0.2 m2; Height: 143.5 mm; Width: 9 mm; Length: 650 mm
Pset_PlateCommon - LoadBearing: no; Reference: K52-44
BaseQuantities - Width: 143.5 mm; NetArea: 0.19969 m2; GrossArea: 0.093275 m2; CrossSectionArea: 0.000081 m2; NetVolume: 0.000835659 m3; GrossVolume: 0.000835659 m3

# IfcPlate: PL9*150 (16)
In: Undefined
Description: PL9*150; Material: STEEL/SS400
Tekla Common - Class: 601
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Height: 150 mm; Width: 9 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 150 mm; CrossSectionArea: 0.000081 m2
Name | Bottom elevation | Top elevation | Phase | Weight (kg) | Area per tons (m2) | Net surface area (m2) | Length (mm) | Reference | NetArea (m2) | GrossArea (m2) | NetVolume (m3) = GrossVolume (m3)
2 x Fu-M20-130 | +18.373 | +18.492 | 7 | 0.9 | 32.5 | 0 | 119 | VS-1 | 0.0323617 | 0.0178497 | 0.000126673
Fu-M20-130 | +18.834 | +18.955 | 1 | 0.9 | 32.5 | 0 | 119 | VS-1 | 0.0323617 | 0.0178497 | 0.000126673
Fu-M20-130 | +18.734 | +18.854 | 1 | 0.9 | 32.5 | 0 | 119 | VS-1 | 0.0323617 | 0.0178497 | 0.000126673
2 x Fu-M20-130 | +18.525 | +18.675 | 7 | 1.6 | 31.6 | 0.1 | 179 | VS-6 | 0.0514417 | 0.0268497 | 0.000207673
2 x Fu-M20-130 | +16.997 | +17.147 | 7 | 1.6 | 31.6 | 0.1 | 179 | VS-6 | 0.0514417 | 0.0268497 | 0.000207673
2 x Fu-M20-130 | +18.525 | +18.675 | 1 | 1.6 | 31.6 | 0.1 | 179 | VS-6 | 0.0514417 | 0.0268497 | 0.000207673
2 x Fu-M20-130 | +17.050 | +17.200 | 1 | 1.6 | 31.6 | 0.1 | 179 | VS-6 | 0.0514417 | 0.0268497 | 0.000207673
2 x Fu-M20-130 | +16.997 | +17.147 | 7 | 0.9 | 32.5 | 0 | 119 | VS-1 | 0.0323617 | 0.0178497 | 0.000126673
2 x Fu-M20-130 | +18.525 | +18.675 | 7 | 0.9 | 32.5 | 0 | 119 | VS-1 | 0.0323617 | 0.0178497 | 0.000126673

# IfcPlate: PL9*154 (3)
In: Undefined
Description: PL9*154; Material: STEEL/SS400
Tekla Common - Preliminary mark: K11-1; Phase: 2; Class: 314
Tekla Quantity - Weight: 2.5 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 31 m2; Net surface area: 0.1 m2; Height: 154.5 mm; Width: 9 mm; Length: 229 mm
Pset_PlateCommon - LoadBearing: no; Reference: K11-1
BaseQuantities - Width: 154.5 mm; NetArea: 0.0770558 m2; GrossArea: 0.0353805 m2; CrossSectionArea: 0.000081 m2; NetVolume: 0.000316399 m3; GrossVolume: 0.000316399 m3
Name | Bottom elevation | Top elevation
STIFFENER | +3.700 | +3.817
STIFFENER | +0.966 | +1.083
STIFFENER | +0.444 | +0.622

# IfcPlate: PL9*155 (5)
In: Undefined
Description: PL9*155; Material: STEEL/SS400
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Net surface area: 0.1 m2; Width: 9 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - CrossSectionArea: 0.000081 m2
Name | Bottom elevation | Top elevation | Preliminary mark = Reference | Phase | Class | Weight (kg) | Area per tons (m2) | Height (mm) = Width (mm) | Length (mm) | NetArea (m2) | GrossArea (m2) | NetVolume (m3) = GrossVolume (m3)
GUSSET | +14.370 | +14.525 | KG-44 | 1 | 5555 | 1.8 | 31.6 | 155 | 190 | 0.0556286 | 0.02945 | 0.00022455
GUSSET | +18.695 | +18.850 | KG-44 | 1 | 5555 | 1.8 | 31.6 | 155 | 190 | 0.0556286 | 0.02945 | 0.00022455
STIFFENER | +3.700 | +3.817 | K11-1 | 2 | 314 | 2.5 | 31 | 154.5 | 229 | 0.0770558 | 0.0353805 | 0.000316399
STIFFENER | +0.966 | +1.083 | K11-1 | 2 | 314 | 2.5 | 31 | 154.5 | 229 | 0.0770558 | 0.0353805 | 0.000316399
STIFFENER | +0.444 | +0.622 | K11-1 | 2 | 314 | 2.5 | 31 | 154.5 | 229 | 0.0770558 | 0.0353805 | 0.000316399

# IfcPlate: PL9*156 (18)
In: Undefined
Description: PL9*156; Material: STEEL/SS400
Tekla Common - Preliminary mark: K11-2; Phase: 2; Class: 314
Tekla Quantity - Weight: 2.6 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 31 m2; Net surface area: 0.1 m2; Height: 156 mm; Width: 9 mm; Length: 241 mm
Pset_PlateCommon - LoadBearing: no; Reference: K11-2
BaseQuantities - Width: 156 mm; NetArea: 0.0817298 m2; GrossArea: 0.037596 m2; CrossSectionArea: 0.000081 m2; NetVolume: 0.000336339 m3; GrossVolume: 0.000336339 m3
Name | Bottom elevation | Top elevation
2 x STIFFENER | +1.271 | +1.394
2 x STIFFENER | +1.977 | +2.100
2 x STIFFENER | +2.683 | +2.806
2 x STIFFENER | +3.389 | +3.512
2 x STIFFENER | +0.671 | +0.858
2 x STIFFENER | +1.274 | +1.460
2 x STIFFENER | +1.876 | +2.063
2 x STIFFENER | +2.478 | +2.665
2 x STIFFENER | +3.081 | +3.267

# IfcPlate: PL9*162 (7)
In: Undefined
Description: PL9*162; Material: STEEL/SS400
Tekla Common - Bottom elevation: +16.809; Top elevation: +16.991; Preliminary mark: K72-29; Phase: 1
Tekla Quantity - Weight: 1.8 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 31.8 m2; Net surface area: 0.1 m2; Height: 161.5 mm; Width: 9 mm; Length: 182.1 mm
Pset_PlateCommon - LoadBearing: no; Reference: K72-29
BaseQuantities - Width: 161.5 mm; NetArea: 0.0544868 m2; GrossArea: 0.0294092 m2; CrossSectionArea: 0.000081 m2; NetVolume: 0.000218604 m3; GrossVolume: 0.000218604 m3
Name | Class
2 x GUSSET | 282
5 x GUSSET | 314

# IfcPlate: PL9*174 (10)
In: Undefined
Description: PL9*174; Material: STEEL/SS400
Tekla Common - Bottom elevation: +4.770; Phase: 1; Class: 314
Tekla Quantity - Volume: 0 m3; Height: 174 mm; Width: 9 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 174 mm; CrossSectionArea: 0.000081 m2
Name | Top elevation | Preliminary mark = Reference | Weight (kg) | Gross footprint area (m2) | Area per tons (m2) | Net surface area (m2) | Length (mm) | NetArea (m2) | GrossArea (m2) | NetVolume (m3) = GrossVolume (m3)
4 x TOP-T_FRANGE | +4.779 | K61-5 | 12.9 | 0.2 | 29.9 | 0.4 | 1050 | 0.387432 | 0.1827 | 0.0016443
3 x GUSSET | +5.124 | K61-8 | 2.8 | 0 | 31.6 | 0.1 | 354 | 0.0899187 | 0.061596 | 0.000362821
3 x GUSSET | +5.124 | K61-7 | 2.8 | 0 | 31.6 | 0.1 | 354 | 0.0897387 | 0.061596 | 0.000362011

# IfcPlate: PL9*185 (2)
In: Undefined
Description: PL9*185; Material: STEEL/SN400B
Tekla Common - Bottom elevation: +18.869; Top elevation: +19.271; Preliminary mark: KG-3; Phase: 1; Class: 314
Tekla Quantity - Weight: 5.2 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 30.4 m2; Net surface area: 0.2 m2; Height: 185 mm; Width: 9 mm; Length: 402 mm
Pset_PlateCommon - LoadBearing: no; Reference: KG-3
BaseQuantities - Width: 185.003 mm; GrossArea: 0.0743715 m2; CrossSectionArea: 0.000081 m2; GrossVolume: 0.000669336 m3
Name | NetArea (m2) | NetVolume (m3)
現場 | 0.157609 | 0.000659482
現場 | 0.15761 | 0.000659491

# IfcPlate: PL9*186 (2)
In: Undefined
Description: PL9*186; Material: STEEL/SS400
Tekla Common - Bottom elevation: +18.861; Top elevation: +19.035; Preliminary mark: K62-233; Phase: 1; Class: 314
Tekla Quantity - Weight: 2 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 31.5 m2; Net surface area: 0.1 m2; Height: 186 mm; Width: 9 mm; Length: 174 mm
Pset_PlateCommon - LoadBearing: no; Reference: K62-233
BaseQuantities - Width: 186 mm; NetArea: 0.0603115 m2; GrossArea: 0.032364 m2; CrossSectionArea: 0.000081 m2; NetVolume: 0.000243951 m3; GrossVolume: 0.000243951 m3

# IfcPlate: PL9*22 (12)
In: Undefined
Description: PL9*22; Material: STEEL/SS400
Tekla Common - Preliminary mark: K11-3; Phase: 2; Class: 314
Tekla Quantity - Weight: 0.4 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 40.6 m2; Net surface area: 0 m2; Height: 22.5 mm; Width: 9 mm; Length: 275 mm
Pset_PlateCommon - LoadBearing: no; Reference: K11-3
BaseQuantities - Width: 22.5 mm; NetArea: 0.01773 m2; GrossArea: 0.0061875 m2; CrossSectionArea: 0.000081 m2; NetVolume: 0.0000556875 m3; GrossVolume: 0.0000556875 m3
Name | Bottom elevation | Top elevation
PLATE | +3.678 | +3.697
PLATE | +3.820 | +3.838
PLATE | +2.664 | +2.683
PLATE | +2.806 | +2.824
PLATE | +3.370 | +3.389
PLATE | +3.512 | +3.530
PLATE | +0.642 | +0.665
PLATE | +0.865 | +0.887
PLATE | +1.244 | +1.267
PLATE | +1.467 | +1.490
PLATE | +1.846 | +1.869
PLATE | +2.069 | +2.092

# IfcPlate: PL9*23 (12)
In: Undefined
Description: PL9*23; Material: STEEL/SS400
Tekla Quantity - Weight: 0.4 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 40.6 m2; Net surface area: 0 m2; Height: 22.5 mm; Width: 9 mm; Length: 275 mm
Pset_PlateCommon - LoadBearing: no; Reference: K11-3
Tekla Common - Preliminary mark: K11-3; Phase: 2; Class: 314
BaseQuantities - Width: 22.5 mm; NetArea: 0.01773 m2; GrossArea: 0.0061875 m2; CrossSectionArea: 0.000081 m2; NetVolume: 0.0000556875 m3; GrossVolume: 0.0000556875 m3
Name | Bottom elevation | Top elevation
PLATE | +0.944 | +0.963
PLATE | +1.086 | +1.104
PLATE | +1.252 | +1.271
PLATE | +1.394 | +1.412
PLATE | +1.958 | +1.977
PLATE | +2.100 | +2.118
PLATE | +0.410 | +0.433
PLATE | +0.633 | +0.656
PLATE | +2.449 | +2.472
PLATE | +2.672 | +2.695
PLATE | +3.051 | +3.074
PLATE | +3.274 | +3.297

# IfcPlate: PL9*234 (2)
In: Undefined
Description: PL9*234; Material: STEEL/SS400
Tekla Common - Bottom elevation: +14.034; Top elevation: +14.360; Preliminary mark: K62-21; Phase: 1; Class: 314
Tekla Quantity - Weight: 3.9 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 30.6 m2; Net surface area: 0.1 m2; Height: 234 mm; Width: 9 mm; Length: 326 mm
Pset_PlateCommon - LoadBearing: no; Reference: K62-21
BaseQuantities - Width: 234 mm; NetArea: 0.121886 m2; GrossArea: 0.076284 m2; CrossSectionArea: 0.000081 m2; NetVolume: 0.000508014 m3; GrossVolume: 0.000508014 m3

# IfcPlate: PL9*246 (8)
In: Undefined
Description: PL9*246; Material: STEEL/SS400
Tekla Common - Class: 314
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Width: 9 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - CrossSectionArea: 0.000081 m2
Name | Bottom elevation | Top elevation | Phase | Weight (kg) | Area per tons (m2) | Net surface area (m2) | Height (mm) = Width (mm) | Length (mm) | Reference | NetArea (m2) | GrossArea (m2) | NetVolume (m3) = GrossVolume (m3) | Preliminary mark
GUSSET | +18.424 | +18.670 | 7 | 2.5 | 31.9 | 0.1 | 246 | 268 | K82-8 | 0.0804877 | 0.065928 | 0.000321533
3 x GUSSET | +13.683 | +14.357 | 1 | 6.9 | 30.6 | 0.2 | 245.5 | 674 | K62-29 | 0.214131 | 0.165467 | 0.000890437 | K62-29
3 x GUSSET | +13.687 | +14.353 | 1 | 6.9 | 30.6 | 0.2 | 245.5 | 666 | K62-30 | 0.212619 | 0.163503 | 0.000884281 | K62-30
GUSSET | +4.783 | +5.457 | 1 | 6.9 | 30.6 | 0.2 | 245.5 | 674 | K61-20 | 0.214131 | 0.165467 | 0.000890437 | K61-20

# IfcPlate: PL9*277 (32)
In: Undefined
Description: PL9*277; Material: STEEL/SS400
Tekla Common - Preliminary mark: K62-23; Phase: 1; Class: 314
Tekla Quantity - Weight: 5.8 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 30.3 m2; Net surface area: 0.2 m2; Height: 276.5 mm; Width: 9 mm; Length: 420 mm
Pset_PlateCommon - LoadBearing: no; Reference: K62-23
BaseQuantities - Width: 276.5 mm; NetArea: 0.176616 m2; GrossArea: 0.11613 m2; CrossSectionArea: 0.000081 m2; NetVolume: 0.000744755 m3; GrossVolume: 0.000744755 m3
Name | Bottom elevation | Top elevation
8 x GUSSET | +19.127 | +19.547
8 x GUSSET | +19.024 | +19.444
8 x GUSSET | +18.967 | +19.387
8 x GUSSET | +18.911 | +19.331

# IfcPlate: PL9*280, PLATE
In: Undefined
Description: PL9*280; Material: STEEL/SS400
Tekla Common - Bottom elevation: +19.048; Top elevation: +19.328; Preliminary mark: K62-309; Phase: 1; Class: 283
Tekla Quantity - Weight: 59.7 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 29.3 m2; Net surface area: 1.8 m2; Height: 280 mm; Width: 9 mm; Length: 3024 mm
Pset_PlateCommon - LoadBearing: no; Reference: K62-309
BaseQuantities - Width: 280 mm; NetArea: 1.75175 m2; GrossArea: 0.84672 m2; CrossSectionArea: 0.000081 m2; NetVolume: 0.00760585 m3; GrossVolume: 0.00762048 m3

# IfcPlate: PL9*294 (22)
In: Undefined
Description: PL9*294; Material: STEEL/SS400
Tekla Common - Phase: 1; Class: 314
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Net surface area: 0.4 m2; Width: 9 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - CrossSectionArea: 0.000081 m2
Name | Bottom elevation | Top elevation | Preliminary mark = Reference | Weight (kg) | Area per tons (m2) | Height (mm) = Width (mm) | Length (mm) | NetArea (m2) | GrossArea (m2) | NetVolume (m3) = GrossVolume (m3)
2 x GUSSET | +13.695 | +14.345 | K52-15 | 10.2 | 29.7 | 293.5 | 650 | 0.30763 | 0.190775 | 0.00131456
7 x GUSSET | +13.699 | +14.349 | K52-32 | 8.9 | 30.3 | 293.5 | 650 | 0.272859 | 0.190775 | 0.00115277
2 x GUSSET | +9.193 | +9.847 | K61-23 | 9.1 | 30.1 | 294 | 654 | 0.274662 | 0.192276 | 0.00116052
GUSSET | +9.199 | +9.849 | K51-6 | 8.9 | 30.3 | 293.5 | 650 | 0.272859 | 0.190775 | 0.00115277
6 x GUSSET | +4.799 | +5.449 | K51-6 | 8.9 | 30.3 | 293.5 | 650 | 0.272859 | 0.190775 | 0.00115277
4 x GUSSET | +4.793 | +5.447 | K61-23 | 9.1 | 30.1 | 294 | 654 | 0.274662 | 0.192276 | 0.00116052

# IfcPlate: PL9*325 (12)
In: Undefined
Description: PL9*325; Material: STEEL/SS400
Tekla Common - Phase: 1; Class: 314
Tekla Quantity - Weight: 6.9 kg; Volume: 0 m3; Gross footprint area: 0 m2; Net surface area: 0.2 m2; Height: 324.5 mm; Width: 9 mm; Length: 406 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 324.5 mm; GrossArea: 0.131747 m2; CrossSectionArea: 0.000081 m2; GrossVolume: 0.000895555 m3
Name | Bottom elevation | Top elevation | Preliminary mark = Reference | Area per tons (m2) | NetArea (m2) | NetVolume (m3)
GUSSET | +18.977 | +19.383 | K52-14 | 30.4 | 0.209288 | 0.000877096
2 x GUSSET | +18.977 | +19.383 | K52-16 | 29.9 | 0.210753 | 0.000895555
3 x GUSSET | +19.033 | +19.439 | K52-16 | 29.9 | 0.210753 | 0.000895555
3 x GUSSET | +19.136 | +19.542 | K52-16 | 29.9 | 0.210753 | 0.000895555
3 x GUSSET | +18.920 | +19.326 | K52-16 | 29.9 | 0.210753 | 0.000895555

# IfcPlate: PL9*37 (2)
In: Undefined
Description: PL9*37; Material: STEEL/SS400
Tekla Common - Phase: 1; Class: 314
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Net surface area: 0 m2; Height: 37 mm; Width: 9 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 37 mm; CrossSectionArea: 0.000081 m2
Name | Bottom elevation | Top elevation | Preliminary mark = Reference | Weight (kg) | Area per tons (m2) | Length (mm) | NetArea (m2) | GrossArea (m2) | NetVolume (m3) = GrossVolume (m3)
STIFFENER | +15.666 | +15.794 | K72-26 | 0.4 | 38 | 128 | 0.0110593 | 0.004736 | 0.0000371134
STIFFENER | +19.465 | +19.548 | K62-44 | 0.2 | 38.1 | 82 | 0.00799765 | 0.003034 | 0.00002673

# IfcPlate: PL9*400, PLATE
In: Undefined
Description: PL9*400; Material: STEEL/SN490B
Tekla Common - Bottom elevation: +4.812; Top elevation: +5.428; Preliminary mark: K51-16; Phase: 1; Class: 314
Tekla Quantity - Weight: 17.4 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 29.4 m2; Net surface area: 0.4 m2; Height: 399.7 mm; Width: 9 mm; Length: 616 mm
Pset_PlateCommon - LoadBearing: no; Reference: K51-16
BaseQuantities - Width: 399.685 mm; NetArea: 0.510694 m2; GrossArea: 0.246206 m2; CrossSectionArea: 0.000081 m2; NetVolume: 0.00221585 m3; GrossVolume: 0.00221585 m3

# IfcPlate: PL9*402 (4)
In: Undefined
Description: PL9*402; Material: STEEL/SN400B
Tekla Common - Bottom elevation: +18.869; Top elevation: +19.271; Phase: 1; Class: 314
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 29 m2; Height: 402 mm; Width: 9 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 402 mm; CrossSectionArea: 0.000081 m2
Name | Preliminary mark = Reference | Weight (kg) | Net surface area (m2) | Length (mm) | NetArea (m2) | GrossArea (m2) | NetVolume (m3) = GrossVolume (m3)
カバーPL | K52-27 | 77.3 | 2.2 | 2723 | 2.24553 | 1.09464 | 0.00985178
カバーPL | K52-26 | 89.2 | 2.6 | 3136 | 2.58503 | 1.26067 | 0.011346
カバーPL | K52-22 | 77.5 | 2.3 | 2729.7 | 2.25108 | 1.09736 | 0.00987621
カバーPL | K52-21 | 89.2 | 2.6 | 3142 | 2.58996 | 1.26309 | 0.0113678

# IfcPlate: PL9*616, PLATE
In: Undefined
Description: PL9*616; Material: STEEL/SN490B
Tekla Common - Bottom elevation: +4.812; Top elevation: +5.428; Preliminary mark: K51-15; Phase: 1; Class: 314
Tekla Quantity - Weight: 33.3 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 29.1 m2; Net surface area: 0.9 m2; Height: 616 mm; Width: 9 mm; Length: 766 mm
Pset_PlateCommon - LoadBearing: no; Reference: K51-15
BaseQuantities - Width: 616 mm; NetArea: 0.968603 m2; GrossArea: 0.471864 m2; CrossSectionArea: 0.000081 m2; NetVolume: 0.00424677 m3; GrossVolume: 0.00424677 m3

# IfcPlate: PL9*62 (65)
In: Undefined
Description: PL9*62; Material: STEEL/SS400
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Net surface area: 0 m2; Height: 61.5 mm; Width: 9 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 61.5 mm; CrossSectionArea: 0.000081 m2
Name | Bottom elevation | Top elevation | Preliminary mark | Phase | Class | Weight (kg) | Area per tons (m2) | Length (mm) | Reference | NetArea (m2) | GrossArea (m2) | NetVolume (m3) | GrossVolume (m3)
STIFFENER | +15.666 | +15.794 | KG-69 | 7 | 314 | 0.4 | 34.7 | 128 | KG-69 | 0.0177723 | 0.007872 | 0.0000653374 | 0.0000653374
STIFFENER | +15.656 | +15.665 | KG-65 | 1 | 290 | 0.4 | 35.2 | 123 | KG-65 | 0.0161271 | 0.0075645 | 0.0000584232 | 0.0000594701
STIFFENER | +15.656 | +15.665 | KG-66 | 1 | 290 | 0.4 | 35.2 | 123 | KG-66 | 0.0161271 | 0.0075645 | 0.0000584232 | 0.0000594701
STIFFENER | +15.795 | +15.804 | KG-66 | 1 | 290 | 0.4 | 35.2 | 123 | KG-66 | 0.0161271 | 0.0075645 | 0.0000584232 | 0.0000594701
STIFFENER | +15.795 | +15.804 | KG-65 | 1 | 290 | 0.4 | 35.2 | 123 | KG-65 | 0.0161271 | 0.0075645 | 0.0000584232 | 0.0000594701
2 x STIFFENER | +17.918 | +17.927 | KG-60 | 1 | 292 | 0.4 | 34.9 | 128 | KG-60 | 0.0170439 | 0.007872 | 0.0000622376 | 0.0000622376
2 x STIFFENER | +17.917 | +17.926 | KG-60 | 1 | 292 | 0.4 | 34.9 | 128 | KG-60 | 0.0170439 | 0.007872 | 0.0000622376 | 0.0000622376
STIFFENER | +14.962 | +14.971 | KG-60 | 1 | 292 | 0.4 | 34.9 | 128 | KG-60 | 0.0170439 | 0.007872 | 0.0000622376 | 0.0000622376
STIFFENER | +14.963 | +14.972 | KG-60 | 1 | 292 | 0.4 | 34.9 | 128 | KG-60 | 0.0170439 | 0.007872 | 0.0000622376 | 0.0000622376
STIFFENER | +15.628 | +15.637 | KG-42 | 7 | 5555 | 0.6 | 34.3 | 128 | KG-42 | 0.0189426 | 0.007872 | 0.000070272 | 0.000070272 | Tekla Common - Finish: 4
STIFFENER | +14.950 | +14.959 | K72-36 | 1 | 282 | 0.4 | 35.2 | 123 | K72-36 | 0.0161271 | 0.0075645 | 0.0000584232 | 0.0000594701
STIFFENER | +14.950 | +14.959 | K72-37 | 1 | 282 | 0.4 | 35.2 | 123 | K72-37 | 0.0161271 | 0.0075645 | 0.0000584232 | 0.0000594701
STIFFENER | +15.656 | +15.665 | K72-36 | 1 | 282 | 0.4 | 35.2 | 123 | K72-36 | 0.0161271 | 0.0075645 | 0.0000584232 | 0.0000594701
STIFFENER | +15.656 | +15.665 | K72-37 | 1 | 282 | 0.4 | 35.2 | 123 | K72-37 | 0.0161271 | 0.0075645 | 0.0000584232 | 0.0000594701
STIFFENER | +15.141 | +15.150 | K72-37 | 1 | 282 | 0.4 | 35.2 | 123 | K72-37 | 0.0161271 | 0.0075645 | 0.0000584232 | 0.0000594701
STIFFENER | +15.141 | +15.150 | K72-36 | 1 | 282 | 0.4 | 35.2 | 123 | K72-36 | 0.0161271 | 0.0075645 | 0.0000584232 | 0.0000594701
STIFFENER | +15.795 | +15.804 | K72-37 | 1 | 282 | 0.4 | 35.2 | 123 | K72-37 | 0.0161271 | 0.0075645 | 0.0000584232 | 0.0000594701
STIFFENER | +15.795 | +15.804 | K72-36 | 1 | 282 | 0.4 | 35.2 | 123 | K72-36 | 0.0161271 | 0.0075645 | 0.0000584232 | 0.0000594701
STIFFENER | +16.800 | +16.809 | K72-36 | 1 | 282 | 0.4 | 35.2 | 123 | K72-36 | 0.0161271 | 0.0075645 | 0.0000584232 | 0.0000594701
STIFFENER | +16.800 | +16.809 | K72-37 | 1 | 282 | 0.4 | 35.2 | 123 | K72-37 | 0.0161271 | 0.0075645 | 0.0000584232 | 0.0000594701
STIFFENER | +16.991 | +17.000 | K72-37 | 1 | 282 | 0.4 | 35.2 | 123 | K72-37 | 0.0161271 | 0.0075645 | 0.0000584232 | 0.0000594701
STIFFENER | +16.991 | +17.000 | K72-36 | 1 | 282 | 0.4 | 35.2 | 123 | K72-36 | 0.0161271 | 0.0075645 | 0.0000584232 | 0.0000594701
2 x STIFFENER | +15.415 | +15.424 |  | 7 | 314 | 0.6 | 34.3 | 128 | K82-23 | 0.0189426 | 0.007872 | 0.000070272 | 0.000070272 | Tekla Common - Finish: 4
2 x STIFFENER | +15.556 | +15.565 |  | 7 | 314 | 0.6 | 34.3 | 128 | K82-23 | 0.0189426 | 0.007872 | 0.000070272 | 0.000070272 | Tekla Common - Finish: 4
3 x STIFFENER | +16.800 | +16.809 | K72-27 | 1 | 314 | 0.4 | 35.2 | 123 | K72-27 | 0.0161271 | 0.0075645 | 0.0000584232 | 0.0000594701
3 x STIFFENER | +16.800 | +16.809 | K72-28 | 1 | 314 | 0.4 | 35.2 | 123 | K72-28 | 0.0161271 | 0.0075645 | 0.0000584232 | 0.0000594701
3 x STIFFENER | +16.991 | +17.000 | K72-28 | 1 | 314 | 0.4 | 35.2 | 123 | K72-28 | 0.0161271 | 0.0075645 | 0.0000584232 | 0.0000594701
3 x STIFFENER | +16.991 | +17.000 | K72-27 | 1 | 314 | 0.4 | 35.2 | 123 | K72-27 | 0.0161271 | 0.0075645 | 0.0000584232 | 0.0000594701
3 x STIFFENER | +14.950 | +14.959 | K72-27 | 1 | 314 | 0.4 | 35.2 | 123 | K72-27 | 0.0161271 | 0.0075645 | 0.0000584232 | 0.0000594701
3 x STIFFENER | +14.950 | +14.959 | K72-28 | 1 | 314 | 0.4 | 35.2 | 123 | K72-28 | 0.0161271 | 0.0075645 | 0.0000584232 | 0.0000594701
3 x STIFFENER | +15.656 | +15.665 | K72-27 | 1 | 314 | 0.4 | 35.2 | 123 | K72-27 | 0.0161271 | 0.0075645 | 0.0000584232 | 0.0000594701
3 x STIFFENER | +15.656 | +15.665 | K72-28 | 1 | 314 | 0.4 | 35.2 | 123 | K72-28 | 0.0161271 | 0.0075645 | 0.0000584232 | 0.0000594701
3 x STIFFENER | +15.141 | +15.150 | K72-28 | 1 | 314 | 0.4 | 35.2 | 123 | K72-28 | 0.0161271 | 0.0075645 | 0.0000584232 | 0.0000594701
3 x STIFFENER | +15.141 | +15.150 | K72-27 | 1 | 314 | 0.4 | 35.2 | 123 | K72-27 | 0.0161271 | 0.0075645 | 0.0000584232 | 0.0000594701
3 x STIFFENER | +15.795 | +15.804 | K72-28 | 1 | 314 | 0.4 | 35.2 | 123 | K72-28 | 0.0161271 | 0.0075645 | 0.0000584232 | 0.0000594701
3 x STIFFENER | +15.795 | +15.804 | K72-27 | 1 | 314 | 0.4 | 35.2 | 123 | K72-27 | 0.0161271 | 0.0075645 | 0.0000584232 | 0.0000594701
STIFFENER | +16.888 | +16.897 |  | 7 | 314 | 0.6 | 34.3 | 128 | K82-28 | 0.0189426 | 0.007872 | 0.000070272 | 0.000070272

# IfcPlate: PL9*641, カバーPL
In: Undefined
Description: PL9*641; Material: STEEL/SS400
Tekla Common - Bottom elevation: +13.683; Top elevation: +14.357; Preliminary mark: K62-59; Phase: 1; Class: 314
Tekla Quantity - Weight: 30.5 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 29.1 m2; Net surface area: 0.9 m2; Height: 641 mm; Width: 9 mm; Length: 674 mm
Pset_PlateCommon - LoadBearing: no; Reference: K62-59
BaseQuantities - Width: 641.005 mm; NetArea: 0.887737 m2; GrossArea: 0.432057 m2; CrossSectionArea: 0.000081 m2; NetVolume: 0.0038883 m3; GrossVolume: 0.0038883 m3

# IfcPlate: PL9*674 (2)
In: Undefined
Description: PL9*674; Material: STEEL/SS400
Tekla Common - Bottom elevation: +13.683; Top elevation: +14.357; Phase: 1; Class: 314
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Height: 674 mm; Width: 9 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 673.995 mm; CrossSectionArea: 0.000081 m2
Name | Preliminary mark = Reference | Weight (kg) | Area per tons (m2) | Net surface area (m2) | Length (mm) | NetArea (m2) | GrossArea (m2) | NetVolume (m3) = GrossVolume (m3)
カバーPL | K62-58 | 137.8 | 28.8 | 4 | 2894 | 3.96531 | 1.95055 | 0.0175549
カバーPL | K62-57 | 43 | 29 | 1.3 | 904 | 1.24697 | 0.609303 | 0.00548357

# IfcPlate: PL9*74 (20)
In: Undefined
Description: PL9*74; Material: STEEL/SS400
Tekla Common - Phase: 1; Class: 314
Tekla Quantity - Weight: 1.8 kg; Volume: 0 m3; Gross footprint area: 0 m2; Net surface area: 0.1 m2; Height: 74 mm; Width: 9 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 74 mm; CrossSectionArea: 0.000081 m2
Name | Bottom elevation | Top elevation | Preliminary mark = Reference | Area per tons (m2) | Length (mm) | NetArea (m2) | GrossArea (m2) | NetVolume (m3) = GrossVolume (m3)
2 x STIFFENER | +14.034 | +14.360 | K62-41 | 32.5 | 326 | 0.0549729 | 0.024124 | 0.000215595
6 x STIFFENER | +4.779 | +5.124 | K61-35 | 32.4 | 345 | 0.0581269 | 0.02553 | 0.000228249

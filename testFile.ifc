Properties of the parts of a building model (IFC2X3), part 2 of 4

# IfcColumn: H-150X150X7X10 (12)
Name | Bottom elevation | Top elevation | Preliminary mark = Reference | Phase | Class | Weight (kg) | Net surface area (m2) | Tekla Quantity, Length (mm) | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
TP15W | +16.820 | +18.835 | P-1490 | 7 | 26 | 62.7 | 1.8 | 2015 | 2014.95 | 1.75757 | 0.00787846 | 61.8459
P15W | +14.816 | +18.833 | P-2523 | 1 | 3 | 125 | 3.6 | 4017 | 4017 | 3.50389 | 0.0156713 | 123.019
2 x P15W | +14.816 | +18.835 | P-2491 | 1 | 3 | 125.1 | 3.6 | 4019 | 4019 | 3.50563 | 0.0156791 | 123.081

# IfcColumn: PL75*120, F1
In: Undefined
Description: PL75*120; Material: STEEL/SS400
Tekla Common - Bottom elevation: -0.154; Top elevation: +4.773; Preliminary mark: P-2798; Phase: 37; Class: 23
Tekla Quantity - Weight: 348.1 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 5.6 m2; Net surface area: 1.9 m2; Height: 120 mm; Width: 75 mm; Length: 4927 mm
Pset_ColumnCommon - LoadBearing: no; Reference: P-2798
BaseQuantities - Length: 4927 mm; OuterSurfaceArea: 1.93953 m2; NetVolume: 0.044343 m3; NetWeight: 348.093 kg

# IfcColumn: PL9*272 (8)
In: Undefined
Description: PL9*272; Material: STEEL/SN490B
Tekla Common - Preliminary mark: SP-5; Phase: 1; Class: 314
Tekla Quantity - Weight: 9.6 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 29.7 m2; Net surface area: 0.4 m2; Height: 272 mm; Width: 9 mm; Length: 500 mm
Pset_ColumnCommon - LoadBearing: no; Reference: SP-5
BaseQuantities - Length: 500 mm; OuterSurfaceArea: 0.285896 m2; NetVolume: 0.001224 m3; NetWeight: 9.6084 kg
Name | Bottom elevation | Top elevation
4 x SPLICE | +9.270 | +9.770
4 x SPLICE | +4.870 | +5.370

# IfcColumn: □-200X100X9, F2
In: Undefined
Description: □-200X100X9; Material: STEEL/STKR400
Tekla Common - Bottom elevation: -0.534; Top elevation: +3.186; Preliminary mark: P-2791; Phase: 37; Class: 22
Tekla Quantity - Weight: 142.1 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 14.9 m2; Net surface area: 2.2 m2; Height: 200 mm; Width: 100 mm; Length: 3720 mm
Pset_ColumnCommon - LoadBearing: no; Reference: P-2791
BaseQuantities - Length: 3720 mm; OuterSurfaceArea: 2.11704 m2; NetVolume: 0.0188467 m3; NetWeight: 147.947 kg

# IfcColumn: □-450X450X19 (14)
In: Undefined
Description: □-450X450X19; Material: STEEL/BCR295
Tekla Common - Phase: 1
Tekla Quantity - Gross footprint area: 0 m2; Area per tons: 7 m2; Height: 450 mm; Width: 450 mm
Pset_ColumnCommon - LoadBearing: no
Name | Bottom elevation | Top elevation | Preliminary mark = Reference | Class | Weight (kg) | Volume (m3) | Net surface area (m2) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
2 x PANEL | +19.093 | +19.477 | A-29 | 328 | 93.2 | 0 | 0.7 | 384.1 | 0.647528 | 0.0125816 | 98.7654
2 x PANEL | +18.878 | +19.262 | A-29 | 328 | 93.2 | 0 | 0.7 | 384.1 | 0.647528 | 0.0125816 | 98.7654
PANEL | +13.713 | +14.327 | A-10 | 328 | 148.9 | 0 | 1.1 | 614 | 1.0351 | 0.0201122 | 157.881
PANEL | +13.718 | +14.322 | A-11 | 328 | 146.5 | 0 | 1.1 | 604 | 1.01824 | 0.0197846 | 155.309
2 x 3C1 | +10.877 | +13.661 | P-261 | 2 | 675.3 | 0.1 | 5 | 2784 | 4.69336 | 0.0911927 | 715.863
4C2 | +14.379 | +19.056 | P-900 | 2 | 1134.5 | 0.1 | 8.5 | 4676.9 | 7.88447 | 0.153197 | 1202.59
4C2A | +14.379 | +19.056 | P-900 | 2 | 1134.5 | 0.1 | 8.5 | 4676.9 | 7.88447 | 0.153197 | 1202.59
2 x 4C1 | +14.379 | +18.841 | P-899 | 2 | 1082.3 | 0.1 | 8.1 | 4461.9 | 7.52201 | 0.146154 | 1147.31
2 x 3C1 | +9.879 | +10.870 | P-259 | 2 | 240.4 | 0 | 1.8 | 991 | 1.67066 | 0.0324612 | 254.82

# IfcColumn: □-450X450X22 (6)
In: Undefined
Description: □-450X450X22; Material: STEEL/BCR295
Tekla Common - Phase: 1
Tekla Quantity - Gross footprint area: 0 m2; Area per tons: 6 m2; Height: 450 mm; Width: 450 mm
Pset_ColumnCommon - LoadBearing: no
Name | Bottom elevation | Top elevation | Preliminary mark = Reference | Class | Weight (kg) | Volume (m3) | Net surface area (m2) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
PANEL | +13.713 | +14.327 | A-27 | 328 | 169.5 | 0 | 1.1 | 614 | 1.02403 | 0.0231257 | 181.537
3C2A | +10.877 | +13.661 | P-430 | 2 | 768.6 | 0.1 | 5.1 | 2784 | 4.64317 | 0.104857 | 823.124
PANEL | +13.711 | +14.335 | A-39 | 328 | 172.3 | 0 | 1.3 | 624 | 1.04071 | 0.0235023 | 184.493
3C2 | +10.877 | +13.661 | P-430 | 2 | 768.6 | 0.1 | 5.1 | 2784 | 4.64317 | 0.104857 | 823.124
3C2 | +9.879 | +10.870 | P-250 | 2 | 273.6 | 0 | 1.8 | 991 | 1.65279 | 0.037325 | 293.001
3C2A | +9.879 | +10.870 | P-250 | 2 | 273.6 | 0 | 1.8 | 991 | 1.65279 | 0.037325 | 293.001

# IfcColumn: □-500X500X19 (8)
In: Undefined
Description: □-500X500X19; Material: STEEL/BCR295
Tekla Common - Phase: 1
Tekla Quantity - Gross footprint area: 0 m2; Area per tons: 6.8 m2; Height: 500 mm; Width: 500 mm
Pset_ColumnCommon - LoadBearing: no
Name | Bottom elevation | Top elevation | Preliminary mark = Reference | Class | Weight (kg) | Volume (m3) | Net surface area (m2) | Tekla Quantity, Length (mm) = BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
PANEL | +9.209 | +9.819 | A-38 | 328 | 166.2 | 0 | 1.3 | 610 | 1.15036 | 0.0222992 | 175.048
PANEL | +9.205 | +9.819 | A-15 | 328 | 167.3 | 0 | 1.3 | 614 | 1.1579 | 0.0224454 | 176.196
PANEL | +4.809 | +5.435 | A-13 | 328 | 170.5 | 0 | 1.3 | 626 | 1.18053 | 0.0228841 | 179.64
PANEL | +4.805 | +5.435 | A-1 | 328 | 171.6 | 0 | 1.3 | 630 | 1.18807 | 0.0230303 | 180.788
2 x 2C1 | +5.479 | +9.161 | P-2 | 2 | 1003 | 0.1 | 7.4 | 3682 | 6.94363 | 0.134599 | 1056.6
2 x 1C1 | -0.400 | +4.761 | P-4 | 2 | 1405.8 | 0.2 | 10.4 | 5161 | 9.73278 | 0.188666 | 1481.02

# IfcColumn: □-500X500X22 (9)
In: Undefined
Description: □-500X500X22; Material: STEEL/BCR295
Tekla Common - Phase: 1
Tekla Quantity - Gross footprint area: 0 m2; Area per tons: 6 m2; Height: 500 mm; Width: 500 mm
Pset_ColumnCommon - LoadBearing: no
Name | Bottom elevation | Top elevation | Preliminary mark = Reference | Class | Weight (kg) | Volume (m3) | Net surface area (m2) | Tekla Quantity, Length (mm) | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
1C2A | +0.090 | +0.392 | P-1191 | 2 | 93.8 | 0 | 0.7 | 302 | 301.999 | 0.564076 | 0.0121797 | 95.6105
1C2A | +0.440 | +4.761 | P-530 | 2 | 1342.1 | 0.2 | 8.7 | 4320.6 | 4320.61 | 8.07005 | 0.181742 | 1426.67
PANEL | +9.213 | +9.819 | A-7 | 328 | 188.2 | 0 | 1.3 | 606 | 606 | 1.13189 | 0.0254908 | 200.103
PANEL | +9.205 | +9.819 | A-6 | 328 | 190.7 | 0 | 1.3 | 614 | 614 | 1.14683 | 0.0258273 | 202.744
2 x PANEL | +4.813 | +5.427 | A-6 | 328 | 190.7 | 0 | 1.3 | 614 | 614 | 1.14683 | 0.0258273 | 202.744
2C2 | +5.479 | +9.161 | P-253 | 2 | 1143.7 | 0.1 | 7.4 | 3682 | 3682 | 6.87725 | 0.15488 | 1215.8
1C2 | -0.400 | +4.761 | P-252 | 2 | 1603.1 | 0.2 | 10.4 | 5161 | 5161 | 9.63974 | 0.217092 | 1704.18
2C2A | +5.479 | +9.161 | P-253 | 2 | 1143.7 | 0.1 | 7.4 | 3682 | 3682 | 6.87725 | 0.15488 | 1215.8

# IfcColumn: ○-60.5X2.3 (76)
In: Undefined
Description: ○-60.5X2.3; Material: STEEL/STK400
Tekla Common - Preliminary mark: P-1559; Phase: 1; Class: 751
Tekla Quantity - Weight: 0.4 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 57.6 m2; Net surface area: 0 m2; Height: 60.5 mm; Width: 60.5 mm; Length: 110 mm
Pset_ColumnCommon - LoadBearing: no; Reference: P-1559
BaseQuantities - Length: 110 mm; OuterSurfaceArea: 0.0209073 m2; NetVolume: 0.0000450789 m3; NetWeight: 0.353869 kg
Name | Bottom elevation | Top elevation
26 x サヤ管 | +14.370 | +14.480
26 x サヤ管 | +9.870 | +9.980
24 x サヤ管 | +5.470 | +5.580

# IfcCovering: 4 (5)
In: Undefined
Material: Undefined/Undefined

# IfcCovering: a (44)
In: Undefined
Material: Undefined/Undefined

# IfcCovering: b (4)
In: Undefined
Material: Undefined/Undefined

# IfcCovering: g
In: Undefined
Material: Undefined/Undefined

# IfcCovering: h
In: Undefined
Material: Undefined/Undefined

# IfcMechanicalFastener: Bolt assembly (624)
In: Undefined
Tekla Bolt - Slotted hole y: 0 mm; Slotted hole x: 0 mm; Location: 現場
Name | NominalDiameter (mm) = Washer diameter (mm) | NominalLength (mm) = Bolt length (mm) | Material | Washer count | Washer type | Washer name | Nut count | Nut type | Nut name | Bolt hole diameter (mm) | Bolt count | Bolt size (mm) | Bolt standard | Bolt Name
Bolt assembly | 16 | 16 | Undefined | 0 | 平座金 | M16-平座金 | 0 | 1種 | M16-1種ﾅｯﾄ | 21 | 4 | 21 | JIS | M16x20
77 x Bolt assembly | 16 | 40 | Undefined | 2 | HTB座金 | M16-HTB座金 | 2 | HTBﾅｯﾄ | M16-HTBﾅｯﾄ | 18 | 2 | 16 | JSS II 09 | M16x40
24 x Bolt assembly | 20 | 45 | Undefined | 2 | HTB座金 | M20-HTB座金 | 2 | HTBﾅｯﾄ | M20-HTBﾅｯﾄ | 22 | 2 | 20 | JSS II 09 | M20x45
5 x Bolt assembly | 16 | 45 | Undefined | 4 | HTB座金 | M16-HTB座金 | 2 | HTBﾅｯﾄ | M16-HTBﾅｯﾄ | 18 | 2 | 16 | JIS B 1186 | M16x45
8 x Bolt assembly | 20 | 50 | Undefined | 4 | HTB座金 | M20-HTB座金 | 2 | HTBﾅｯﾄ | M20-HTBﾅｯﾄ | 22 | 2 | 20 | JIS B 1186 | M20x50
5 x Bolt assembly | 16 | 16 | Undefined | 0 | 平座金 | M16-平座金 | 0 | 1種 | M16-1種ﾅｯﾄ | 21 | 2 | 21 | JIS | M16x20
11 x Bolt assembly | 16 | 35 | Undefined | 2 | HTB座金 | M16-HTB座金 | 2 | HTBﾅｯﾄ | M16-HTBﾅｯﾄ | 18 | 2 | 16 | JSS II 09 | M16x35
6 x Bolt assembly | 20 | 45 | Undefined | 2 | HTB座金 | M20-HTB座金 | 1 | HTBﾅｯﾄ | M20-HTBﾅｯﾄ | 22 | 1 | 20 | JIS B 1186 | M20x45
18 x Bolt assembly | 20 | 50 | Undefined | 3 | HTB座金 | M20-HTB座金 | 3 | HTBﾅｯﾄ | M20-HTBﾅｯﾄ | 22 | 3 | 20 | JSS II 09 | M20x50
6 x Bolt assembly | 16 | 50 | Undefined | 2 | HTB座金 | M16-HTB座金 | 2 | HTBﾅｯﾄ | M16-HTBﾅｯﾄ | 18 | 2 | 16 | JSS II 09 | M16x50
4 x Bolt assembly | 20 | 55 | Undefined | 2 | HTB座金 | M20-HTB座金 | 1 | HTBﾅｯﾄ | M20-HTBﾅｯﾄ | 22 | 1 | 20 | JIS B 1186 | M20x55
4 x Bolt assembly | 20 | 50 | Undefined | 1 | HTB座金 | M20-HTB座金 | 1 | HTBﾅｯﾄ | M20-HTBﾅｯﾄ | 22 | 1 | 20 | JSS II 09 | M20x50
Bolt assembly | 20 | 56 | Undefined | 2 | HTB座金 | M20-HTB座金 | 2 | HTBﾅｯﾄ | M20-HTBﾅｯﾄ | 22 | 2 | 20 | JSS II 09 | M20x60
2 x Bolt assembly | 16 | 40 | Undefined | 4 | HTB座金 | M16-HTB座金 | 2 | HTBﾅｯﾄ | M16-HTBﾅｯﾄ | 18 | 2 | 16 | JIS B 1186 | M16x40
13 x Bolt assembly | 20 | 50 | Undefined | 2 | HTB座金 | M20-HTB座金 | 2 | HTBﾅｯﾄ | M20-HTBﾅｯﾄ | 22 | 2 | 20 | JSS II 09 | M20x50
195 x Bolt assembly | 12 | 35 | Undefined | 4 | 平座金 | M12-平座金 | 2 | 1種 | M12-1種ﾅｯﾄ | 14 | 2 | 12 | JIS | M12x35
2 x Bolt assembly | 16 | 45 | Undefined | 2 | HTB座金 | M16-HTB座金 | 2 | HTBﾅｯﾄ | M16-HTBﾅｯﾄ | 18 | 2 | 16 | JSS II 09 | M16x45
4 x Bolt assembly | 20 | 60 | Undefined | 5 | HTB座金 | M20-HTB座金 | 5 | HTBﾅｯﾄ | M20-HTBﾅｯﾄ | 22 | 5 | 20 | JSS II 09 | M20x60
8 x Bolt assembly | 20 | 60 | Undefined | 16 | HTB座金 | M20-HTB座金 | 16 | HTBﾅｯﾄ | M20-HTBﾅｯﾄ | 22 | 16 | 20 | JSS II 09 | M20x60
19 x Bolt assembly | 20 | 60 | Undefined | 8 | HTB座金 | M20-HTB座金 | 8 | HTBﾅｯﾄ | M20-HTBﾅｯﾄ | 22 | 8 | 20 | JSS II 09 | M20x60
4 x Bolt assembly | 20 | 50 | Undefined | 9 | HTB座金 | M20-HTB座金 | 9 | HTBﾅｯﾄ | M20-HTBﾅｯﾄ | 22 | 9 | 20 | JSS II 09 | M20x50
8 x Bolt assembly | 12 | 16 | 7990 | 0 |  |  | 0 |  |  | 42 | 1 | 42 | 7990
31 x Bolt assembly | 20 | 50 | Undefined | 2 | HTB座金 | M20-HTB座金 | 2 | HTBﾅｯﾄ | M20-HTBﾅｯﾄ | 21.5 | 2 | 20 | JSS II 09 | M20x50
Bolt assembly | 20 | 60 | Undefined | 9 | HTB座金 | M20-HTB座金 | 9 | HTBﾅｯﾄ | M20-HTBﾅｯﾄ | 22 | 9 | 20 | JSS II 09 | M20x60
55 x Bolt assembly | 20 | 50 | Undefined | 10 | HTB座金 | M20-HTB座金 | 10 | HTBﾅｯﾄ | M20-HTBﾅｯﾄ | 22 | 10 | 20 | JSS II 09 | M20x50
27 x Bolt assembly | 20 | 45 | Undefined | 5 | HTB座金 | M20-HTB座金 | 5 | HTBﾅｯﾄ | M20-HTBﾅｯﾄ | 22 | 5 | 20 | JSS II 09 | M20x45
12 x Bolt assembly | 20 | 50 | Undefined | 5 | HTB座金 | M20-HTB座金 | 5 | HTBﾅｯﾄ | M20-HTBﾅｯﾄ | 22 | 5 | 20 | JSS II 09 | M20x50
15 x Bolt assembly | 20 | 50 | Undefined | 4 | HTB座金 | M20-HTB座金 | 4 | HTBﾅｯﾄ | M20-HTBﾅｯﾄ | 22 | 4 | 20 | JSS II 09 | M20x50
2 x Bolt assembly | 20 | 55 | Undefined | 5 | HTB座金 | M20-HTB座金 | 5 | HTBﾅｯﾄ | M20-HTBﾅｯﾄ | 22 | 5 | 20 | JSS II 09 | M20x55
44 x Bolt assembly | 20 | 55 | Undefined | 3 | HTB座金 | M20-HTB座金 | 3 | HTBﾅｯﾄ | M20-HTBﾅｯﾄ | 22 | 3 | 20 | JSS II 09 | M20x55
12 x Bolt assembly | 24 | 29 | Undefined | 0 | 平座金 | M24-平座金 | 0 | 1種 | M24-1種ﾅｯﾄ | 50 | 2 | 50 | JIS | M24x30

# IfcMember: BH275X275X12X22 (3)
In: Undefined
Description: BH275X275X12X22; Material: STEEL/SN490B
Tekla Common - Phase: 2; Class: 10
Tekla Quantity - Weight: 88.8 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 14.3 m2; Net surface area: 1.3 m2; Height: 275 mm; Width: 275 mm; Length: 768 mm
Pset_MemberCommon - LoadBearing: no
BaseQuantities - CrossSectionArea: 0.014872 m2
Name | Bottom elevation | Top elevation | Reference | Length (mm) | OuterSurfaceArea (m2) | GrossSurfaceArea (m2) | NetVolume (m3) | GrossVolume (m3) | NetWeight (kg) | GrossWeight (kg)
A27H | +0.020 | +0.735 | P-712 | 768.002 | 1.27084 | 1.27851 | 0.0113161 | 0.0114217 | 88.8315 | 89.6605
A27H | +3.561 | +4.357 | P-846 | 768.003 | 1.27084 | 1.27852 | 0.0113162 | 0.0114217 | 88.8319 | 89.6606
A27H | +0.415 | +1.222 | P-712 | 768.014 | 1.27085 | 1.27853 | 0.0113162 | 0.0114219 | 88.8324 | 89.6619

# IfcMember: BH275X275X9X16 (2)
In: Undefined
Description: BH275X275X9X16; Material: STEEL/SN490B
Tekla Common - Phase: 2; Class: 10
Tekla Quantity - Gross footprint area: 0 m2; Area per tons: 18.9 m2; Height: 275 mm; Width: 275 mm
Pset_MemberCommon - LoadBearing: no
BaseQuantities - CrossSectionArea: 0.010987 m2
Name | Bottom elevation | Top elevation | Preliminary mark = Reference | Weight (kg) | Volume (m3) | Net surface area (m2) | Tekla Quantity, Length (mm) | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) | GrossSurfaceArea (m2) | NetVolume (m3) | GrossVolume (m3) | NetWeight (kg) | GrossWeight (kg)
A27H | +0.537 | +4.005 | P-698 | 425.8 | 0.1 | 8.1 | 4947.1 | 4947.11 | 8.08451 | 8.09565 | 0.0542415 | 0.0543539 | 425.796 | 426.678
A27H | +1.099 | +3.684 | P-516 | 241.3 | 0 | 4.6 | 2807.6 | 2807.6 | 4.59282 | 4.60395 | 0.0307347 | 0.0308469 | 241.267 | 242.148

# IfcMember: L-65X65X6 (3)
In: Undefined
Description: L-65X65X6; Material: STEEL/SS400
Tekla Common - Phase: 39; Class: 73
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 42.8 m2; Net surface area: 0.4 m2; Height: 65 mm; Width: 65 mm
Pset_MemberCommon - LoadBearing: no
BaseQuantities - CrossSectionArea: 0.0007527 m2
Name | Bottom elevation | Top elevation | Preliminary mark = Reference | Weight (kg) | Tekla Quantity, Length (mm) | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) = GrossSurfaceArea (m2) | NetVolume (m3) | GrossVolume (m3) | NetWeight (kg) | GrossWeight (kg)
L65 | +18.411 | +19.374 | P-2832 | 10.2 | 1721.9 | 1721.91 | 0.435501 | 0.0012811 | 0.00129608 | 10.0566 | 10.1742
L65 | +18.405 | +19.274 | P-2831 | 9.9 | 1676.2 | 1676.2 | 0.423942 | 0.0012471 | 0.00126168 | 9.7897 | 9.90418
L65 | +18.399 | +19.165 | P-2830 | 9.6 | 1631.2 | 1631.25 | 0.412572 | 0.00121365 | 0.00122784 | 9.52713 | 9.63854

# IfcMember: L-90X90X10 (3)
In: Undefined
Description: L-90X90X10; Material: STEEL/SS400
Tekla Common - Phase: 7; Class: 28
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 26.2 m2; Net surface area: 0.4 m2; Height: 90 mm; Width: 90 mm
Pset_MemberCommon - LoadBearing: no
BaseQuantities - CrossSectionArea: 0.0017 m2
Name | Bottom elevation | Top elevation | Preliminary mark = Reference | Weight (kg) | Tekla Quantity, Length (mm) | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) = GrossSurfaceArea (m2) | NetVolume (m3) = GrossVolume (m3) | NetWeight (kg) = GrossWeight (kg)
L90 | +18.381 | +18.835 | P-2220 | 11.7 | 877.3 | 877.329 | 0.306801 | 0.00149146 | 11.7079
L90 | +18.416 | +19.184 | P-2569 | 16 | 1199.7 | 1199.68 | 0.419525 | 0.00203945 | 16.0097
L90 | +18.401 | +19.050 | P-2194 | 14.6 | 1092.9 | 1092.92 | 0.382193 | 0.00185796 | 14.585

# IfcMember: M20 (2)
In: Undefined
Description: M20; Material: STEEL/SNR400B
Tekla Common - Bottom elevation: +17.091; Top elevation: +18.581; Preliminary mark: P-2196; Phase: 7; Class: 7
Tekla Quantity - Weight: 4.6 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 25.5 m2; Net surface area: 0.1 m2; Height: 20 mm; Width: 20 mm; Length: 1918.4 mm
Pset_MemberCommon - LoadBearing: no; Reference: P-2196
BaseQuantities - Length: 1918.42 mm; OuterSurfaceArea: 0.120538 m2; GrossSurfaceArea: 0.120538 m2; CrossSectionArea: 0.000314 m2; NetVolume: 0.00054261 m3; GrossVolume: 0.000602383 m3; NetWeight: 4.25949 kg; GrossWeight: 4.7287 kg

# IfcMember: □-350X350X12 (2)
In: Undefined
Description: □-350X350X12; Material: STEEL/BCR295
Tekla Common - Phase: 2; Class: 7
Tekla Quantity - Volume: 0.1 m3; Gross footprint area: 0 m2; Area per tons: 10.8 m2; Height: 350 mm; Width: 350 mm
Pset_MemberCommon - LoadBearing: no
BaseQuantities - CrossSectionArea: 0.01573 m2
Name | Bottom elevation | Top elevation | Preliminary mark = Reference | Weight (kg) | Net surface area (m2) | Tekla Quantity, Length (mm) | BaseQuantities, Length (mm) | OuterSurfaceArea (m2) = GrossSurfaceArea (m2) | NetVolume (m3) | GrossVolume (m3) | NetWeight (kg) | GrossWeight (kg)
A27H | +0.170 | +4.371 | P-714 | 734.4 | 8.3 | 5947.1 | 5947.11 | 8.01965 | 0.0964859 | 0.093548 | 757.414 | 734.352
A27H | +0.633 | +4.149 | P-503 | 470.2 | 5.3 | 3807.6 | 3807.58 | 5.13451 | 0.0617743 | 0.0598933 | 484.928 | 470.162

# IfcPlate: PL1.6*80, FILLER
In: Undefined
Description: PL1.6*80; Material: STEEL/SS400
Tekla Common - Bottom elevation: +19.228; Top elevation: +19.368; Preliminary mark: SP-19; Phase: 1; Class: 314
Tekla Quantity - Weight: 0.1 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 164.2 m2; Net surface area: 0 m2; Height: 80 mm; Width: 1.6 mm; Length: 140 mm
Pset_PlateCommon - LoadBearing: no; Reference: SP-19
BaseQuantities - Width: 80 mm; NetArea: 0.023104 m2; GrossArea: 0.0112 m2; CrossSectionArea: 0.00000256 m2; NetVolume: 0.00001792 m3; GrossVolume: 0.00001792 m3

# IfcPlate: PL12*100, PLATE
In: Undefined
Description: PL12*100; Material: STEEL/SS400
Tekla Common - Bottom elevation: +4.803; Top elevation: +4.815; Preliminary mark: F-19; Phase: 1; Class: 314
Tekla Quantity - Weight: 4.3 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 25 m2; Net surface area: 0.1 m2; Height: 100 mm; Width: 12 mm; Length: 485 mm
Pset_PlateCommon - LoadBearing: no; Reference: F-19
BaseQuantities - Width: 100 mm; NetArea: 0.107486 m2; GrossArea: 0.0484996 m2; CrossSectionArea: 0.000144 m2; NetVolume: 0.000547075 m3; GrossVolume: 0.000581995 m3

# IfcPlate: PL12*133, STIFFENER
In: Undefined
Description: PL12*133; Material: STEEL/SS400
Tekla Common - Bottom elevation: +4.803; Top elevation: +5.437; Preliminary mark: K51-91; Phase: 1; Class: 314
Tekla Quantity - Weight: 7.9 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 23.5 m2; Net surface area: 0.2 m2; Height: 133 mm; Width: 12 mm; Length: 634 mm
Pset_PlateCommon - LoadBearing: no; Reference: K51-91
BaseQuantities - Width: 133 mm; NetArea: 0.186151 m2; GrossArea: 0.084322 m2; CrossSectionArea: 0.000144 m2; NetVolume: 0.00100798 m3; GrossVolume: 0.00100798 m3

# IfcPlate: PL12*134 (12)
In: Undefined
Description: PL12*134; Material: STEEL/SS400
Tekla Common - Phase: 1; Class: 314
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 23.5 m2; Net surface area: 0.2 m2; Width: 12 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - CrossSectionArea: 0.000144 m2
Name | Bottom elevation | Top elevation | Preliminary mark = Reference | Weight (kg) | Height (mm) = Width (mm) | Length (mm) | NetArea (m2) | GrossArea (m2) | NetVolume (m3) = GrossVolume (m3)
STIFFENER | +9.199 | +9.849 | K51-92 | 8.1 | 133.5 | 650 | 0.191453 | 0.086775 | 0.00103741
STIFFENER | +9.193 | +9.847 | K61-122 | 8.2 | 134 | 654 | 0.193283 | 0.087636 | 0.00104774
STIFFENER | +13.695 | +14.345 | K52-123 | 8.1 | 133.5 | 650 | 0.191453 | 0.086775 | 0.00103741
5 x STIFFENER | +9.195 | +9.845 | K51-92 | 8.1 | 133.5 | 650 | 0.191453 | 0.086775 | 0.00103741
4 x STIFFENER | +4.795 | +5.445 | K51-92 | 8.1 | 133.5 | 650 | 0.191453 | 0.086775 | 0.00103741

# IfcPlate: PL12*135, STIFFENER
In: Undefined
Description: PL12*135; Material: STEEL/SS400
Tekla Common - Bottom elevation: +18.869; Top elevation: +19.271; Preliminary mark: K62-119; Phase: 1; Class: 314
Tekla Quantity - Weight: 5.2 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 23.7 m2; Net surface area: 0.1 m2; Height: 134.5 mm; Width: 12 mm; Length: 402 mm
Pset_PlateCommon - LoadBearing: no; Reference: K62-119
BaseQuantities - Width: 134.5 mm; NetArea: 0.120493 m2; GrossArea: 0.054069 m2; CrossSectionArea: 0.000144 m2; NetVolume: 0.0006468 m3; GrossVolume: 0.0006468 m3

# IfcPlate: PL12*144 (4)
In: Undefined
Description: PL12*144; Material: STEEL/SN490B
Tekla Common - Preliminary mark: K51-88; Phase: 1; Class: 314
Tekla Quantity - Weight: 8.9 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 23.5 m2; Net surface area: 0.2 m2; Height: 143.5 mm; Width: 12 mm; Length: 651 mm
Pset_PlateCommon - LoadBearing: no; Reference: K51-88
BaseQuantities - Width: 143.5 mm; NetArea: 0.204496 m2; GrossArea: 0.0934185 m2; CrossSectionArea: 0.000144 m2; NetVolume: 0.00111505 m3; GrossVolume: 0.00111505 m3
Name | Bottom elevation | Top elevation
2 x GUSSET | +9.195 | +9.846
2 x GUSSET | +4.795 | +5.446

# IfcPlate: PL12*145 (2)
In: Undefined
Description: PL12*145; Material: STEEL/SS400
Tekla Common - Bottom elevation: +18.869; Top elevation: +19.271; Preliminary mark: K52-134; Phase: 1; Class: 314
Tekla Quantity - Weight: 5.4 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 23.6 m2; Net surface area: 0.1 m2; Height: 144.5 mm; Width: 12 mm; Length: 402 mm
Pset_PlateCommon - LoadBearing: no; Reference: K52-134
BaseQuantities - Width: 144.5 mm; NetArea: 0.128433 m2; GrossArea: 0.058089 m2; CrossSectionArea: 0.000144 m2; NetVolume: 0.00069384 m3; GrossVolume: 0.00069384 m3

# IfcPlate: PL12*165, GUSSET
In: Undefined
Description: PL12*165; Material: STEEL/SS400
Tekla Common - Bottom elevation: +18.685; Top elevation: +18.850; Preliminary mark: K52-228; Phase: 1; Class: 314
Tekla Quantity - Weight: 3.7 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 24.5 m2; Net surface area: 0.1 m2; Height: 165 mm; Width: 12 mm; Length: 398.1 mm
Pset_PlateCommon - LoadBearing: no; Reference: K52-228
BaseQuantities - Width: 165.034 mm; NetArea: 0.0892681 m2; GrossArea: 0.0657011 m2; CrossSectionArea: 0.000144 m2; NetVolume: 0.000465279 m3; GrossVolume: 0.000465279 m3

# IfcPlate: PL12*173, GUSSET
In: Undefined
Description: PL12*173; Material: STEEL/SS400
Tekla Common - Bottom elevation: +18.892; Top elevation: +19.065; Preliminary mark: K52-229; Phase: 1; Class: 314
Tekla Quantity - Weight: 2.9 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 24.5 m2; Net surface area: 0.1 m2; Height: 173.5 mm; Width: 12 mm; Length: 296.2 mm
Pset_PlateCommon - LoadBearing: no; Reference: K52-229
BaseQuantities - Width: 173.477 mm; NetArea: 0.071916 m2; GrossArea: 0.0513846 m2; CrossSectionArea: 0.000144 m2; NetVolume: 0.000374406 m3; GrossVolume: 0.000381491 m3

# IfcPlate: PL12*178, GUSSET
In: Undefined
Description: PL12*178; Material: STEEL/SS400
Tekla Common - Bottom elevation: +19.022; Top elevation: +19.199; Preliminary mark: K62-296; Phase: 1; Class: 314
Tekla Quantity - Weight: 3.2 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 24.5 m2; Net surface area: 0.1 m2; Height: 177.6 mm; Width: 12 mm; Length: 313.5 mm
Pset_PlateCommon - LoadBearing: no; Reference: K62-296
BaseQuantities - Width: 177.628 mm; NetArea: 0.0774974 m2; GrossArea: 0.0556932 m2; CrossSectionArea: 0.000144 m2; NetVolume: 0.000405278 m3; GrossVolume: 0.000405278 m3

# IfcPlate: PL12*184, GUSSET
In: Undefined
Description: PL12*184; Material: STEEL/SS400
Tekla Common - Bottom elevation: +18.344; Top elevation: +18.531; Phase: 7; Class: 314
Tekla Quantity - Weight: 2.5 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 24.5 m2; Net surface area: 0.1 m2; Height: 184.2 mm; Width: 12 mm; Length: 186.1 mm
Pset_PlateCommon - LoadBearing: no; Reference: K82-39
BaseQuantities - Width: 184.233 mm; NetArea: 0.0578137 m2; GrossArea: 0.0342862 m2; CrossSectionArea: 0.000144 m2; NetVolume: 0.000300817 m3; GrossVolume: 0.000300817 m3

# IfcPlate: PL12*185, GUSSET
In: Undefined
Description: PL12*185; Material: STEEL/SS400
Tekla Common - Bottom elevation: +13.683; Top elevation: +14.357; Preliminary mark: K62-110; Phase: 1; Class: 314
Tekla Quantity - Weight: 7.2 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 24 m2; Net surface area: 0.2 m2; Height: 185.5 mm; Width: 12 mm; Length: 674 mm
Pset_PlateCommon - LoadBearing: no; Reference: K62-110
BaseQuantities - Width: 185.5 mm; NetArea: 0.173589 m2; GrossArea: 0.125027 m2; CrossSectionArea: 0.000144 m2; NetVolume: 0.000920129 m3; GrossVolume: 0.000920129 m3

# IfcPlate: PL12*186 (15)
In: Undefined
Description: PL12*186
Tekla Common - Phase: 1; Class: 314
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Height: 185.5 mm; Width: 12 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 185.5 mm; CrossSectionArea: 0.000144 m2
Name | Material | Bottom elevation | Top elevation | Preliminary mark = Reference | Weight (kg) | Area per tons (m2) | Net surface area (m2) | Length (mm) | NetArea (m2) | GrossArea (m2) | NetVolume (m3) = GrossVolume (m3)
6 x GUSSET | STEEL/SS400 | +13.683 | +14.357 | K62-86 | 11.1 | 23 | 0.4 | 674 | 0.258909 | 0.125027 | 0.00143205
4 x GUSSET | STEEL/SS400 | +13.687 | +14.353 | K62-89 | 11.1 | 23 | 0.4 | 666 | 0.257349 | 0.123543 | 0.00142384
GUSSET | STEEL/SS400 | +13.683 | +14.357 | K62-109 | 6.7 | 24.2 | 0.2 | 674 | 0.162909 | 0.125027 | 0.000856049
2 x GUSSET | STEEL/SS400 | +9.183 | +9.857 | K61-46 | 6.7 | 24.2 | 0.2 | 674 | 0.162909 | 0.125027 | 0.000856049
GUSSET | STEEL/SN490B | +13.683 | +14.357 | K62-64 | 11.1 | 23 | 0.4 | 674 | 0.258909 | 0.125027 | 0.00143205
GUSSET | STEEL/SS400 | +4.787 | +5.453 | K61-54 | 11.1 | 23 | 0.4 | 666 | 0.257349 | 0.123543 | 0.00142384

# IfcPlate: PL12*187 (2)
In: Undefined
Description: PL12*187; Material: STEEL/SS400
Tekla Common - Phase: 7; Class: 314
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 24.5 m2; Net surface area: 0.1 m2; Width: 12 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - CrossSectionArea: 0.000144 m2
Name | Bottom elevation | Top elevation | Weight (kg) | Height (mm) | Length (mm) | Reference | Width (mm) | NetArea (m2) | GrossArea (m2) | NetVolume (m3) = GrossVolume (m3)
GUSSET | +18.352 | +18.560 | 2.5 | 186.6 | 208.3 | K82-40 | 186.631 | 0.0618938 | 0.0388836 | 0.000323083
GUSSET | +18.356 | +18.579 | 2.6 | 187 | 222.7 | K82-38 | 187.046 | 0.0643124 | 0.0416468 | 0.000336151

# IfcPlate: PL12*200 (9)
In: Undefined
Description: PL12*200; Material: STEEL/SS400
Tekla Common - Phase: 1
Tekla Quantity - Volume: 0 m3; Height: 200 mm; Width: 12 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 200 mm; CrossSectionArea: 0.000144 m2
Name | Bottom elevation | Top elevation | Preliminary mark = Reference | Class | Weight (kg) | Gross footprint area (m2) | Area per tons (m2) | Net surface area (m2) | Length (mm) | NetArea (m2) | GrossArea (m2) | NetVolume (m3) = GrossVolume (m3)
PLATE | +19.328 | +19.340 | K62-310 | 283 | 57 | 0.6 | 22.6 | 1.3 | 3024 | 1.28698 | 0.6048 | 0.0072576
8 x STIFFENER | -0.390 | -0.090 | K1-29 | 314 | 4.3 | 0 | 23.7 | 0.1 | 300 | 0.100664 | 0.06 | 0.00053865

# IfcPlate: PL12*208 (9)
In: Undefined
Description: PL12*208; Material: STEEL/SS400
Tekla Common - Preliminary mark: K62-144; Phase: 1; Class: 314
Tekla Quantity - Weight: 3.3 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 24 m2; Net surface area: 0.1 m2; Height: 207.6 mm; Width: 12 mm
Pset_PlateCommon - LoadBearing: no; Reference: K62-144
BaseQuantities - CrossSectionArea: 0.000144 m2
Name | Bottom elevation | Top elevation | Length (mm) | Width (mm) | NetArea (m2) | GrossArea (m2) | NetVolume (m3) | GrossVolume (m3)
2 x GUSSET | +19.433 | +19.450 | 262.6 | 207.61 | 0.0793552 | 0.0545266 | 0.000422165 | 0.000468616
2 x GUSSET | +19.314 | +19.330 | 262.6 | 207.622 | 0.0793606 | 0.0545312 | 0.000422195 | 0.00046866
GUSSET | +19.433 | +19.450 | 262.8 | 207.61 | 0.0794024 | 0.0545544 | 0.000422427 | 0.000468616
GUSSET | +19.314 | +19.330 | 262.4 | 207.622 | 0.0792866 | 0.0544878 | 0.000421785 | 0.00046866
2 x GUSSET | +19.530 | +19.546 | 262.6 | 207.62 | 0.0793565 | 0.0545285 | 0.000422173 | 0.000468651
GUSSET | +19.530 | +19.546 | 262.6 | 207.61 | 0.0793458 | 0.054521 | 0.000422113 | 0.000468616

# IfcPlate: PL12*212 (13)
In: Undefined
Description: PL12*212; Material: STEEL/SS400
Tekla Common - Preliminary mark: K62-143; Phase: 1; Class: 314
Tekla Quantity - Weight: 3.4 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 24 m2; Net surface area: 0.1 m2; Height: 211.8 mm; Width: 12 mm
Pset_PlateCommon - LoadBearing: no; Reference: K62-143
BaseQuantities - CrossSectionArea: 0.000144 m2
Name | Bottom elevation | Top elevation | Length (mm) | Width (mm) | NetArea (m2) | GrossArea (m2) | NetVolume (m3) | GrossVolume (m3)
2 x GUSSET | +19.321 | +19.337 | 265.7 | 211.804 | 0.0815154 | 0.0562822 | 0.000434419 | 0.000485487
2 x GUSSET | +19.427 | +19.443 | 265.5 | 211.804 | 0.0814505 | 0.0562408 | 0.000434059 | 0.000485487
GUSSET | +19.427 | +19.443 | 265.5 | 211.804 | 0.0814518 | 0.0562416 | 0.000434066 | 0.000485487
GUSSET | +19.377 | +19.393 | 265.7 | 211.804 | 0.0814792 | 0.0562591 | 0.000434218 | 0.000485487
GUSSET | +19.371 | +19.387 | 265.5 | 211.804 | 0.0814155 | 0.0562185 | 0.000433865 | 0.000485487
GUSSET | +19.377 | +19.393 | 265.7 | 211.804 | 0.0814805 | 0.0562599 | 0.000434226 | 0.000485487
GUSSET | +19.321 | +19.337 | 265.5 | 211.808 | 0.0814491 | 0.0562403 | 0.000434052 | 0.000485506
GUSSET | +19.371 | +19.387 | 265.5 | 211.808 | 0.0814193 | 0.0562213 | 0.000433887 | 0.000485506
2 x GUSSET | +19.537 | +19.553 | 265.5 | 211.806 | 0.0814494 | 0.0562403 | 0.000434053 | 0.000485497
GUSSET | +19.537 | +19.553 | 265.5 | 211.806 | 0.0814513 | 0.0562415 | 0.000434064 | 0.000485497

# IfcPlate: PL12*233 (4)
In: Undefined
Description: PL12*233
Tekla Common - Phase: 1; Class: 314
Tekla Quantity - Weight: 13.8 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 22.7 m2; Net surface area: 0.4 m2; Height: 233 mm; Width: 12 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 233 mm; CrossSectionArea: 0.000144 m2
Name | Material | Bottom elevation | Top elevation | Preliminary mark = Reference | Length (mm) | NetArea (m2) | GrossArea (m2) | NetVolume (m3) = GrossVolume (m3)
GUSSET | STEEL/SN490B | +4.800 | +5.437 | K51-55 | 637 | 0.312543 | 0.148421 | 0.00175225
GUSSET | STEEL/SS400 | +4.800 | +5.437 | K51-78 | 637 | 0.312543 | 0.148421 | 0.00175225
GUSSET | STEEL/SN490B | +13.700 | +14.340 | K52-69 | 640 | 0.312623 | 0.14912 | 0.00175239
GUSSET | STEEL/SS400 | +13.700 | +14.340 | K52-74 | 640 | 0.312623 | 0.14912 | 0.00175239

# IfcPlate: PL12*234 (40)
In: Undefined
Description: PL12*234
Tekla Common - Phase: 1; Class: 314
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Width: 12 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - CrossSectionArea: 0.000144 m2
Name | Material | Bottom elevation | Top elevation | Preliminary mark = Reference | Weight (kg) | Area per tons (m2) | Net surface area (m2) | Height (mm) = Width (mm) | Length (mm) | NetArea (m2) | GrossArea (m2) | NetVolume (m3) = GrossVolume (m3)
GUSSET | STEEL/SS400 | +13.695 | +14.350 | K52-117 | 9.5 | 23.5 | 0.2 | 233.5 | 655 | 0.221901 | 0.152943 | 0.00120583
5 x GUSSET | STEEL/SS400 | +9.193 | +9.847 | K61-56 | 14.2 | 22.7 | 0.4 | 234 | 654 | 0.319611 | 0.153036 | 0.00179216
GUSSET | STEEL/SN490B | +13.695 | +14.345 | K52-68 | 14 | 22.7 | 0.4 | 233.5 | 650 | 0.317781 | 0.151775 | 0.00178183
GUSSET | STEEL/SN490B | +9.195 | +9.845 | K51-51 | 14 | 22.7 | 0.4 | 233.5 | 650 | 0.317781 | 0.151775 | 0.00178183
2 x GUSSET | STEEL/SN490B | +4.795 | +5.445 | K51-51 | 14 | 22.7 | 0.4 | 233.5 | 650 | 0.317781 | 0.151775 | 0.00178183
GUSSET | STEEL/SS400 | +13.699 | +14.349 | K52-70 | 14 | 22.7 | 0.4 | 233.5 | 650 | 0.317781 | 0.151775 | 0.00178183
5 x GUSSET | STEEL/SS400 | +13.695 | +14.345 | K52-71 | 14 | 22.7 | 0.4 | 233.5 | 650 | 0.317781 | 0.151775 | 0.00178183
10 x GUSSET | STEEL/SS400 | +9.195 | +9.845 | K51-73 | 14 | 22.7 | 0.4 | 233.5 | 650 | 0.317781 | 0.151775 | 0.00178183
GUSSET | STEEL/SS400 | +9.195 | +9.845 | K51-69 | 9.5 | 23.5 | 0.2 | 233.5 | 650 | 0.221772 | 0.151775 | 0.00120561
8 x GUSSET | STEEL/SS400 | +4.795 | +5.445 | K51-73 | 14 | 22.7 | 0.4 | 233.5 | 650 | 0.317781 | 0.151775 | 0.00178183
2 x GUSSET | STEEL/SS400 | +4.793 | +5.447 | K61-56 | 14.2 | 22.7 | 0.4 | 234 | 654 | 0.319611 | 0.153036 | 0.00179216
3 x GUSSET | STEEL/SS400 | +9.199 | +9.849 | K51-72 | 14 | 22.7 | 0.4 | 233.5 | 650 | 0.317781 | 0.151775 | 0.00178183

# IfcPlate: PL12*235 (3)
In: Undefined
Description: PL12*235; Material: STEEL/SS400
Tekla Common - Bottom elevation: +18.869; Top elevation: +19.271; Phase: 1; Class: 314
Tekla Quantity - Weight: 6.4 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 23.6 m2; Net surface area: 0.2 m2; Height: 234.5 mm; Width: 12 mm; Length: 402 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 234.5 mm; NetArea: 0.150822 m2; GrossArea: 0.094269 m2; CrossSectionArea: 0.000144 m2; NetVolume: 0.000815213 m3; GrossVolume: 0.000815213 m3
Name | Preliminary mark = Reference
2 x GUSSET | K52-118
GUSSET | K62-111

# IfcPlate: PL12*242 (10)
In: Undefined
Description: PL12*242; Material: STEEL/SS400
Tekla Common - Phase: 1; Class: 314
Tekla Quantity - Weight: 8.2 kg; Volume: 0 m3; Gross footprint area: 0 m2; Net surface area: 0.2 m2; Width: 12 mm; Length: 402 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - CrossSectionArea: 0.000144 m2
Name | Bottom elevation | Top elevation | Preliminary mark = Reference | Area per tons (m2) | Height (mm) | Width (mm) | NetArea (m2) | GrossArea (m2) | NetVolume (m3) = GrossVolume (m3)
GUSSET | +18.869 | +19.271 | K52-90 | 23 | 242.4 | 242.439 | 0.191524 | 0.0974604 | 0.00105877
GUSSET | +19.084 | +19.486 | K52-89 | 23.1 | 242.4 | 242.443 | 0.189884 | 0.0974619 | 0.00104893
GUSSET | +19.084 | +19.486 | K52-88 | 23.1 | 242.2 | 242.16 | 0.189815 | 0.0973484 | 0.00104853
4 x GUSSET | +19.084 | +19.486 | K52-84 | 23.1 | 242.2 | 242.334 | 0.189886 | 0.0974184 | 0.00104894
3 x GUSSET | +18.869 | +19.271 | K52-85 | 23.1 | 242.4 | 242.439 | 0.189886 | 0.0974604 | 0.00104894

# IfcPlate: PL12*243 (4)
In: Undefined
Description: PL12*243; Material: STEEL/SS400
Tekla Common - Bottom elevation: +19.084; Top elevation: +19.486; Preliminary mark: K52-85; Phase: 1; Class: 314
Tekla Quantity - Weight: 8.2 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 23.1 m2; Net surface area: 0.2 m2; Height: 242.6 mm; Width: 12 mm; Length: 402 mm
Pset_PlateCommon - LoadBearing: no; Reference: K52-85
BaseQuantities - Width: 242.623 mm; NetArea: 0.189957 m2; GrossArea: 0.0975344 m2; CrossSectionArea: 0.000144 m2; NetVolume: 0.00104935 m3; GrossVolume: 0.00104935 m3

# IfcPlate: PL12*245 (9)
In: Undefined
Description: PL12*245; Material: STEEL/SS400
Tekla Common - Preliminary mark: K52-103; Phase: 1; Class: 314
Tekla Quantity - Weight: 3.3 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 24 m2; Net surface area: 0.1 m2; Width: 12 mm
Pset_PlateCommon - LoadBearing: no; Reference: K52-103
BaseQuantities - CrossSectionArea: 0.000144 m2
Name | Bottom elevation | Top elevation | Height (mm) | Length (mm) | Width (mm) | NetArea (m2) | GrossArea (m2) | NetVolume (m3) | GrossVolume (m3)
2 x GUSSET | +19.469 | +19.485 | 245.1 | 185.2 | 245.118 | 0.0793683 | 0.0453965 | 0.000422244 | 0.000763664
2 x GUSSET | +19.262 | +19.278 | 245.1 | 185.2 | 245.115 | 0.0793682 | 0.0453974 | 0.000422236 | 0.000767498
GUSSET | +19.469 | +19.485 | 245.1 | 185.2 | 245.118 | 0.0793683 | 0.0453965 | 0.000422236 | 0.000765675
GUSSET | +19.262 | +19.278 | 245.1 | 185.2 | 245.115 | 0.0793682 | 0.0453974 | 0.000422243 | 0.000765485
2 x GUSSET | +19.477 | +19.493 | 244.9 | 184.6 | 244.865 | 0.0790687 | 0.0452046 | 0.000420542 | 0.000767862
GUSSET | +19.477 | +19.493 | 245.1 | 185.2 | 245.119 | 0.0793511 | 0.0453848 | 0.000422146 | 0.000767466

# IfcPlate: PL12*279, PLATE
In: Undefined
Description: PL12*279; Material: STEEL/SN490B
Tekla Common - Bottom elevation: -0.390; Top elevation: +0.052; Preliminary mark: K1-47; Phase: 1; Class: 314
Tekla Quantity - Weight: 11.7 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 22.7 m2; Net surface area: 0.4 m2; Height: 279 mm; Width: 12 mm; Length: 442.4 mm
Pset_PlateCommon - LoadBearing: no; Reference: K1-47
BaseQuantities - Width: 279.002 mm; NetArea: 0.264173 m2; GrossArea: 0.12343 m2; CrossSectionArea: 0.000144 m2; NetVolume: 0.00148116 m3; GrossVolume: 0.00148116 m3

# IfcPlate: PL12*366 (12)
In: Undefined
Description: PL12*366; Material: STEEL/SS400
Tekla Common - Bottom elevation: +13.683; Top elevation: +14.357; Preliminary mark: K62-78; Phase: 1; Class: 314
Tekla Quantity - Weight: 15.3 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 22.7 m2; Net surface area: 0.4 m2; Height: 365.5 mm; Width: 12 mm; Length: 674 mm
Pset_PlateCommon - LoadBearing: no; Reference: K62-78
BaseQuantities - Width: 365.5 mm; NetArea: 0.348672 m2; GrossArea: 0.246347 m2; CrossSectionArea: 0.000144 m2; NetVolume: 0.00195953 m3; GrossVolume: 0.00195953 m3

# IfcPlate: PL12*376, PLATE
In: Undefined
Description: PL12*376; Material: STEEL/SN490B
Tekla Common - Bottom elevation: +4.388; Top elevation: +4.764; Preliminary mark: K51-63; Phase: 1; Class: 314
Tekla Quantity - Weight: 22.4 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 22.6 m2; Net surface area: 0.4 m2; Height: 375.9 mm; Width: 12 mm; Length: 939 mm
Pset_PlateCommon - LoadBearing: no; Reference: K51-63
BaseQuantities - Width: 375.877 mm; NetArea: 0.505638 m2; GrossArea: 0.352949 m2; CrossSectionArea: 0.000144 m2; NetVolume: 0.00285374 m3; GrossVolume: 0.0029991 m3

# IfcPlate: PL12*399, GUSSET
In: Undefined
Description: PL12*399; Material: STEEL/SS400
Tekla Common - Bottom elevation: +18.861; Top elevation: +19.260; Preliminary mark: K62-223; Phase: 1; Class: 314
Tekla Quantity - Weight: 5.7 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 24 m2; Net surface area: 0.1 m2; Height: 399 mm; Width: 12 mm; Length: 280 mm
Pset_PlateCommon - LoadBearing: no; Reference: K62-223
BaseQuantities - Width: 399 mm; NetArea: 0.136575 m2; GrossArea: 0.11172 m2; CrossSectionArea: 0.000144 m2; NetVolume: 0.000723753 m3; GrossVolume: 0.000723753 m3

# IfcPlate: PL12*400 (3)
In: Undefined
Description: PL12*400; Material: STEEL/SN490B
Tekla Common - Preliminary mark: K11-5; Phase: 2; Class: 314
Tekla Quantity - Weight: 12.9 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 24.2 m2; Net surface area: 0.4 m2; Height: 400 mm; Width: 12 mm; Length: 400 mm
Pset_PlateCommon - LoadBearing: no; Reference: K11-5
BaseQuantities - Width: 400 mm; NetArea: 0.314138 m2; GrossArea: 0.16 m2; CrossSectionArea: 0.000144 m2; NetVolume: 0.00165393 m3; GrossVolume: 0.00192 m3
Name | Bottom elevation | Top elevation
端部補強PL | +0.143 | +0.451
端部補強PL | +3.971 | +4.172
端部補強PL | +0.611 | +0.812

# IfcPlate: PL12*414 (3)
In: Undefined
Description: PL12*414; Material: STEEL/SS400
Tekla Common - Bottom elevation: +13.695; Top elevation: +14.345; Preliminary mark: K52-67; Phase: 1; Class: 314
Tekla Quantity - Weight: 18 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 22.5 m2; Net surface area: 0.4 m2; Height: 413.5 mm; Width: 12 mm; Length: 650 mm
Pset_PlateCommon - LoadBearing: no; Reference: K52-67
BaseQuantities - Width: 413.5 mm; NetArea: 0.404202 m2; GrossArea: 0.268775 m2; CrossSectionArea: 0.000144 m2; NetVolume: 0.00228915 m3; GrossVolume: 0.00228915 m3

# IfcPlate: PL12*465, GUSSET
In: Undefined
Description: PL12*465; Material: STEEL/SS400
Tekla Common - Bottom elevation: +18.868; Top elevation: +19.271; Preliminary mark: K52-176; Phase: 1; Class: 314
Tekla Quantity - Weight: 9.5 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 23.5 m2; Net surface area: 0.2 m2; Height: 464.5 mm; Width: 12 mm; Length: 403 mm
Pset_PlateCommon - LoadBearing: no; Reference: K52-176
BaseQuantities - Width: 464.5 mm; NetArea: 0.220766 m2; GrossArea: 0.187193 m2; CrossSectionArea: 0.000144 m2; NetVolume: 0.00120161 m3; GrossVolume: 0.00120161 m3

# IfcPlate: PL12*484, PLATE
In: Undefined
Description: PL12*484; Material: STEEL/SN490B
Tekla Common - Bottom elevation: +4.280; Top elevation: +4.764; Preliminary mark: K51-62; Phase: 1; Class: 314
Tekla Quantity - Weight: 15.6 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 22.6 m2; Net surface area: 0.4 m2; Height: 483.9 mm; Width: 12 mm; Length: 506.3 mm
Pset_PlateCommon - LoadBearing: no; Reference: K51-62
BaseQuantities - Width: 483.906 mm; NetArea: 0.352699 m2; GrossArea: 0.24502 m2; CrossSectionArea: 0.000144 m2; NetVolume: 0.00198675 m3; GrossVolume: 0.00208652 m3

# IfcPlate: PL12*50 (3)
In: Undefined
Description: PL12*50; Material: STEEL/SS400
Tekla Common - Preliminary mark: K11-6; Phase: 2; Class: 314
Tekla Quantity - Weight: 0.4 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 29.7 m2; Net surface area: 0 m2; Height: 50 mm; Width: 12 mm; Length: 75 mm
Pset_PlateCommon - LoadBearing: no; Reference: K11-6
BaseQuantities - Width: 50 mm; NetArea: 0.0105 m2; GrossArea: 0.00375 m2; CrossSectionArea: 0.000144 m2; NetVolume: 0.000045 m3; GrossVolume: 0.000045 m3
Name | Bottom elevation | Top elevation
PLATE | +4.054 | +4.143
PLATE | +0.551 | +0.641
PLATE | +0.103 | +0.190

# IfcPlate: PL12*503, GUSSET
In: Undefined
Description: PL12*503; Material: STEEL/SS400
Tekla Common - Bottom elevation: +4.803; Top elevation: +5.437; Preliminary mark: K51-170; Phase: 1; Class: 314
Tekla Quantity - Weight: 14.9 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 23 m2; Net surface area: 0.4 m2; Height: 503 mm; Width: 12 mm; Length: 634 mm
Pset_PlateCommon - LoadBearing: no; Reference: K51-170
BaseQuantities - Width: 502.996 mm; NetArea: 0.343023 m2; GrossArea: 0.318899 m2; CrossSectionArea: 0.000144 m2; NetVolume: 0.00189625 m3; GrossVolume: 0.00189625 m3

# IfcPlate: PL12*691, PLATE
In: Undefined
Description: PL12*691; Material: STEEL/SN490B
Tekla Common - Bottom elevation: -0.390; Top elevation: +0.185; Preliminary mark: K1-40; Phase: 1; Class: 314
Tekla Quantity - Weight: 25.6 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 22.3 m2; Net surface area: 0.7 m2; Height: 691.1 mm; Width: 12 mm; Length: 575.4 mm
Pset_PlateCommon - LoadBearing: no; Reference: K1-40
BaseQuantities - Width: 691.126 mm; NetArea: 0.569371 m2; GrossArea: 0.39767 m2; CrossSectionArea: 0.000144 m2; NetVolume: 0.0032587 m3; GrossVolume: 0.00328714 m3

# IfcPlate: PL12*86 (16)
In: Undefined
Description: PL12*86
Tekla Common - Phase: 1; Class: 314
Tekla Quantity - Weight: 5.4 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 24.6 m2; Net surface area: 0.1 m2; Height: 85.5 mm; Width: 12 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 85.5 mm; CrossSectionArea: 0.000144 m2
Name | Material | Bottom elevation | Top elevation | Preliminary mark = Reference | Length (mm) | NetArea (m2) | GrossArea (m2) | NetVolume (m3) = GrossVolume (m3)
2 x STIFFENER | STEEL/SS400 | +9.183 | +9.857 | K61-119 | 674 | 0.132581 | 0.057627 | 0.000687636
6 x STIFFENER | STEEL/SS400 | +9.183 | +9.857 | K61-128 | 674 | 0.132401 | 0.057627 | 0.000686724
5 x STIFFENER | STEEL/SS400 | +13.683 | +14.357 | K62-113 | 674 | 0.132581 | 0.057627 | 0.000687636
STIFFENER | STEEL/SS400 | +13.687 | +14.353 | K62-116 | 666 | 0.131021 | 0.056943 | 0.000679428
STIFFENER | STEEL/SN490B | +13.683 | +14.357 | K62-67 | 674 | 0.132581 | 0.057627 | 0.000687636
STIFFENER | STEEL/SS400 | +4.787 | +5.453 | K61-120 | 666 | 0.131021 | 0.056943 | 0.000679428

# IfcPlate: PL12*872, PLATE
In: Undefined
Description: PL12*872; Material: STEEL/SN490B
Tekla Common - Bottom elevation: -0.390; Top elevation: +0.503; Preliminary mark: K1-31; Phase: 1; Class: 314
Tekla Quantity - Weight: 57.8 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 22.1 m2; Net surface area: 1.3 m2; Height: 872.2 mm; Width: 12 mm; Length: 892.5 mm
Pset_PlateCommon - LoadBearing: no; Reference: K1-31
BaseQuantities - Width: 872.202 mm; NetArea: 1.28107 m2; GrossArea: 0.778458 m2; CrossSectionArea: 0.000144 m2; NetVolume: 0.00736809 m3; GrossVolume: 0.0076299 m3

# IfcPlate: PL12*90, GUSSET
In: Undefined
Description: PL12*90; Material: STEEL/SS400
Tekla Common - Bottom elevation: +4.810; Top elevation: +5.430; Preliminary mark: K51-67; Phase: 1; Class: 314
Tekla Quantity - Weight: 4.8 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 25.2 m2; Net surface area: 0.1 m2; Height: 90 mm; Width: 12 mm; Length: 620 mm
Pset_PlateCommon - LoadBearing: no; Reference: K51-67
BaseQuantities - Width: 90 mm; NetArea: 0.124138 m2; GrossArea: 0.0558 m2; CrossSectionArea: 0.000144 m2; NetVolume: 0.00062496 m3; GrossVolume: 0.0006696 m3

# IfcPlate: PL12*95 (3)
In: Undefined
Description: PL12*95; Material: STEEL/SS400
Tekla Common - Bottom elevation: +18.404; Top elevation: +18.416; Preliminary mark: K2-23; Phase: 1; Class: 314
Tekla Quantity - Weight: 1.8 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 25.2 m2; Net surface area: 0 m2; Height: 95 mm; Width: 12 mm; Length: 200 mm
Pset_PlateCommon - LoadBearing: no; Reference: K2-23
BaseQuantities - Width: 95 mm; NetArea: 0.04508 m2; GrossArea: 0.019 m2; CrossSectionArea: 0.000144 m2; NetVolume: 0.000228 m3; GrossVolume: 0.000228 m3

# IfcPlate: PL12*96, STIFFENER
In: Undefined
Description: PL12*96; Material: STEEL/SS400
Tekla Common - Bottom elevation: +13.683; Top elevation: +14.357; Preliminary mark: K62-124; Phase: 1; Class: 314
Tekla Quantity - Weight: 6 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 24.2 m2; Net surface area: 0.1 m2; Height: 95.5 mm; Width: 12 mm; Length: 674 mm
Pset_PlateCommon - LoadBearing: no; Reference: K62-124
BaseQuantities - Width: 95.5 mm; NetArea: 0.146301 m2; GrossArea: 0.064367 m2; CrossSectionArea: 0.000144 m2; NetVolume: 0.000768516 m3; GrossVolume: 0.000768516 m3

# IfcPlate: PL12*99, PLATE
In: Undefined
Description: PL12*99; Material: STEEL/SN400B
Tekla Common - Bottom elevation: +19.196; Top elevation: +19.210; Preliminary mark: K52-79; Phase: 1; Class: 314
Tekla Quantity - Weight: 2.8 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 24.7 m2; Net surface area: 0.1 m2; Height: 99 mm; Width: 12 mm; Length: 300 mm
Pset_PlateCommon - LoadBearing: no; Reference: K52-79
BaseQuantities - Width: 99 mm; NetArea: 0.068976 m2; GrossArea: 0.0297 m2; CrossSectionArea: 0.000144 m2; NetVolume: 0.0003564 m3; GrossVolume: 0.0003564 m3

# IfcPlate: PL16*126 (8)
In: Undefined
Description: PL16*126; Material: STEEL/SS400
Tekla Common - Preliminary mark: P-1486; Phase: 1; Class: 520
Tekla Quantity - Weight: 1.2 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 21.9 m2; Net surface area: 0 m2; Height: 125.7 mm; Width: 16 mm; Length: 113.3 mm
Pset_PlateCommon - LoadBearing: no; Reference: P-1486
BaseQuantities - Width: 125.652 mm; NetArea: 0.0260764 m2; GrossArea: 0.0142406 m2; CrossSectionArea: 0.000256 m2; NetVolume: 0.000151395 m3; GrossVolume: 0.000151395 m3
Name | Bottom elevation | Top elevation
4 x K6 | +19.508 | +19.608
4 x K6 | +19.293 | +19.393

# IfcPlate: PL16*174 (2)
In: Undefined
Description: PL16*174; Material: STEEL/SN490B
Tekla Common - Phase: 1; Class: 314
Tekla Quantity - Volume: 0 m3; Area per tons: 18.2 m2; Height: 174 mm; Width: 16 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 174 mm; CrossSectionArea: 0.000256 m2
Name | Bottom elevation | Top elevation | Preliminary mark = Reference | Weight (kg) | Gross footprint area (m2) | Net surface area (m2) | Length (mm) | NetArea (m2) | GrossArea (m2) | NetVolume (m3) = GrossVolume (m3)
TOP_TF | +9.178 | +9.194 | K61-136 | 6.7 | 0.1 | 0.1 | 300 | 0.119568 | 0.0522 | 0.0008352
GUSSET | +9.194 | +9.860 | K61-133 | 12.9 | 0 | 0.2 | 666 | 0.23381 | 0.115884 | 0.00163973

# IfcPlate: PL16*186 (4)
In: Undefined
Description: PL16*186; Material: STEEL/SN490B
Tekla Common - Phase: 1; Class: 314
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Height: 185.5 mm; Width: 16 mm; Length: 674 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 185.5 mm; GrossArea: 0.125027 m2; CrossSectionArea: 0.000256 m2
Name | Bottom elevation | Top elevation | Preliminary mark = Reference | Weight (kg) | Area per tons (m2) | Net surface area (m2) | NetArea (m2) | NetVolume (m3) = GrossVolume (m3)
2 x GUSSET | +13.683 | +14.357 | K62-2 | 14.2 | 17.8 | 0.4 | 0.253654 | 0.0018134
GUSSET | +9.183 | +9.857 | K61-139 | 13.5 | 17.9 | 0.2 | 0.241654 | 0.0017174
GUSSET | +4.783 | +5.457 | K61-139 | 13.5 | 17.9 | 0.2 | 0.241654 | 0.0017174

# IfcPlate: PL16*191 (2)
In: Undefined
Description: PL16*191; Material: STEEL/SS400
Tekla Common - Bottom elevation: +9.183; Top elevation: +9.857; Preliminary mark: K61-182; Phase: 1; Class: 314
Tekla Quantity - Weight: 13.2 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 17.9 m2; Net surface area: 0.2 m2; Height: 191.4 mm; Width: 16 mm; Length: 674 mm
Pset_PlateCommon - LoadBearing: no; Reference: K61-182
BaseQuantities - Width: 191.352 mm; NetArea: 0.23671 m2; GrossArea: 0.128971 m2; CrossSectionArea: 0.000256 m2; NetVolume: 0.00168708 m3; GrossVolume: 0.00168708 m3

# IfcPlate: PL16*234, GUSSET
In: Undefined
Description: PL16*234; Material: STEEL/SN490B
Tekla Common - Bottom elevation: +9.195; Top elevation: +9.845; Preliminary mark: K51-124; Phase: 1; Class: 314
Tekla Quantity - Weight: 17.1 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 17.4 m2; Net surface area: 0.4 m2; Height: 233.5 mm; Width: 16 mm; Length: 650 mm
Pset_PlateCommon - LoadBearing: no; Reference: K51-124
BaseQuantities - Width: 233.5 mm; NetArea: 0.300718 m2; GrossArea: 0.151775 m2; CrossSectionArea: 0.000256 m2; NetVolume: 0.00218377 m3; GrossVolume: 0.00218377 m3

# IfcPlate: PL16*300, TOP_TW
In: Undefined
Description: PL16*300; Material: STEEL/SN490B
Tekla Common - Bottom elevation: +9.194; Top elevation: +9.524; Preliminary mark: K61-137; Phase: 1; Class: 314
Tekla Quantity - Weight: 12.4 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 17.4 m2; Net surface area: 0.2 m2; Height: 300 mm; Width: 16 mm; Length: 330 mm
Pset_PlateCommon - LoadBearing: no; Reference: K61-137
BaseQuantities - Width: 300 mm; NetArea: 0.218161 m2; GrossArea: 0.0990005 m2; CrossSectionArea: 0.000256 m2; NetVolume: 0.00158401 m3; GrossVolume: 0.00158401 m3

# IfcPlate: PL16*69, STIFFENER
In: Undefined
Description: PL16*69; Material: STEEL/SN490B
Tekla Common - Bottom elevation: +9.194; Top elevation: +9.524; Preliminary mark: K61-156; Phase: 1; Class: 314
Tekla Quantity - Weight: 2.8 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 20.3 m2; Net surface area: 0.1 m2; Height: 69 mm; Width: 16 mm; Length: 330 mm
Pset_PlateCommon - LoadBearing: no; Reference: K61-156
BaseQuantities - Width: 69 mm; NetArea: 0.0577266 m2; GrossArea: 0.0227701 m2; CrossSectionArea: 0.000256 m2; NetVolume: 0.000361618 m3; GrossVolume: 0.000361618 m3

# IfcPlate: PL16*74, STIFFENER
In: Undefined
Description: PL16*74; Material: STEEL/SN490B
Tekla Common - Bottom elevation: +9.534; Top elevation: +9.860; Preliminary mark: K61-155; Phase: 1; Class: 314
Tekla Quantity - Weight: 2.9 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 20.1 m2; Net surface area: 0.1 m2; Height: 74 mm; Width: 16 mm; Length: 326 mm
Pset_PlateCommon - LoadBearing: no; Reference: K61-155
BaseQuantities - Width: 74 mm; NetArea: 0.0604663 m2; GrossArea: 0.024124 m2; CrossSectionArea: 0.000256 m2; NetVolume: 0.00038328 m3; GrossVolume: 0.00038328 m3

# IfcPlate: PL16*77 (4)
In: Undefined
Description: PL16*77; Material: STEEL/SS400
Tekla Common - Bottom elevation: +13.683; Top elevation: +14.357; Preliminary mark: K62-8; Phase: 1; Class: 314
Tekla Quantity - Weight: 6.4 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 19.6 m2; Net surface area: 0.1 m2; Height: 76.5 mm; Width: 16 mm; Length: 674 mm
Pset_PlateCommon - LoadBearing: no; Reference: K62-8
BaseQuantities - Width: 76.5 mm; NetArea: 0.126153 m2; GrossArea: 0.051561 m2; CrossSectionArea: 0.000256 m2; NetVolume: 0.000819792 m3; GrossVolume: 0.000819792 m3

# IfcPlate: PL16*86 (6)
In: Undefined
Description: PL16*86
Tekla Common - Phase: 1; Class: 314
Tekla Quantity - Weight: 7.2 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 19.3 m2; Net surface area: 0.1 m2; Height: 85.5 mm; Width: 16 mm; Length: 674 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 85.5 mm; GrossArea: 0.057627 m2; CrossSectionArea: 0.000256 m2
Name | Material | Bottom elevation | Top elevation | Preliminary mark = Reference | NetArea (m2) | NetVolume (m3) = GrossVolume (m3)
2 x STIFFENER | STEEL/SS400 | +9.183 | +9.857 | K61-164 | 0.138383 | 0.000915632
2 x STIFFENER | STEEL/SN490B | +13.683 | +14.357 | K62-6 | 0.138573 | 0.000916848
STIFFENER | STEEL/SN490B | +9.183 | +9.857 | K61-150 | 0.138573 | 0.000916848
STIFFENER | STEEL/SN490B | +4.783 | +5.457 | K61-150 | 0.138573 | 0.000916848

# IfcPlate: PL16*96 (4)
In: Undefined
Description: PL16*96; Material: STEEL/SS400
Tekla Common - Bottom elevation: +13.683; Top elevation: +14.357; Preliminary mark: K62-11; Phase: 1; Class: 314
Tekla Quantity - Weight: 7.9 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 18.9 m2; Net surface area: 0.2 m2; Height: 95.5 mm; Width: 16 mm; Length: 674 mm
Pset_PlateCommon - LoadBearing: no; Reference: K62-11
BaseQuantities - Width: 95.5 mm; NetArea: 0.151985 m2; GrossArea: 0.064367 m2; CrossSectionArea: 0.000256 m2; NetVolume: 0.00102309 m3; GrossVolume: 0.00102309 m3

# IfcPlate: PL22*104, PLATE
In: Undefined
Description: PL22*104; Material: STEEL/SN490B
Tekla Common - Bottom elevation: +0.423; Top elevation: +0.513; Preliminary mark: K1-63; Phase: 1; Class: 314
Tekla Quantity - Weight: 4.6 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 15.4 m2; Net surface area: 0.1 m2; Height: 104 mm; Width: 22 mm; Length: 275 mm
Pset_PlateCommon - LoadBearing: no; Reference: K1-63
BaseQuantities - Width: 104.041 mm; NetArea: 0.0706612 m2; GrossArea: 0.0286114 m2; CrossSectionArea: 0.000484 m2; NetVolume: 0.000582852 m3; GrossVolume: 0.000629451 m3

# IfcPlate: PL22*265, PLATE
In: Undefined
Description: PL22*265; Material: STEEL/SN490B
Tekla Common - Bottom elevation: +0.067; Top elevation: +0.202; Preliminary mark: K1-67; Phase: 1; Class: 314
Tekla Quantity - Weight: 12.1 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 13.7 m2; Net surface area: 0.2 m2; Height: 264.7 mm; Width: 22 mm; Length: 275 mm
Pset_PlateCommon - LoadBearing: no; Reference: K1-67
BaseQuantities - Width: 264.729 mm; NetArea: 0.164572 m2; GrossArea: 0.0728005 m2; CrossSectionArea: 0.000484 m2; NetVolume: 0.00153721 m3; GrossVolume: 0.00160161 m3

# IfcPlate: PL22*275 (5)
In: Undefined
Description: PL22*275; Material: STEEL/SN490B
Tekla Common - Phase: 1; Class: 314
Tekla Quantity - Volume: 0 m3; Gross footprint area: 0 m2; Height: 275 mm; Width: 22 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 275 mm; CrossSectionArea: 0.000484 m2
Name | Bottom elevation | Top elevation | Preliminary mark = Reference | Weight (kg) | Area per tons (m2) | Net surface area (m2) | Length (mm) | NetArea (m2) | GrossArea (m2) | NetVolume (m3) | GrossVolume (m3)
PLATE | -0.384 | -0.005 | K1-55 | 21.4 | 13.2 | 0.4 | 466.3 | 0.282602 | 0.128232 | 0.00272791 | 0.0028211
PLATE | +4.369 | +4.589 | K51-117 | 38 | 12.9 | 0.4 | 815.7 | 0.490146 | 0.224317 | 0.00484178 | 0.00493497
PLATE | -0.384 | +0.381 | K1-64 | 36.5 | 12.9 | 0.4 | 783.9 | 0.47127 | 0.215578 | 0.00464952 | 0.00474272
PLATE | +4.269 | +4.582 | K51-115 | 19.1 | 13.2 | 0.4 | 410 | 0.25238 | 0.11274 | 0.00243369 | 0.00248029
PLATE | +4.402 | +4.764 | K51-114 | 17 | 13.4 | 0.2 | 372.6 | 0.226939 | 0.102462 | 0.00216097 | 0.00225417

# IfcPlate: PL25*100, PLATE
In: Undefined
Description: PL25*100; Material: STEEL/SS400
Tekla Common - Bottom elevation: +4.773; Top elevation: +5.013; Preliminary mark: F-7; Phase: 37; Class: 314
Tekla Quantity - Weight: 4.6 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 13.7 m2; Net surface area: 0.1 m2; Height: 100 mm; Width: 25 mm; Length: 240 mm
Pset_PlateCommon - LoadBearing: no; Reference: F-7
BaseQuantities - Width: 100 mm; NetArea: 0.0637121 m2; GrossArea: 0.024 m2; CrossSectionArea: 0.000625 m2; NetVolume: 0.00059074 m3; GrossVolume: 0.0006 m3

# IfcPlate: PL25*204 (21)
In: Undefined
Description: PL25*204; Material: STEEL/SN490B
Tekla Common - Phase: 1; Class: 99
Tekla Quantity - Weight: 2 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 26.7 m2; Net surface area: 0.1 m2; Height: 203.7 mm; Width: 25 mm; Length: 203.7 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 203.711 mm; NetArea: 0.0520194 m2; GrossArea: 0.0414982 m2; CrossSectionArea: 0.000625 m2; NetVolume: 0.00024804 m3; GrossVolume: 0.000797736 m3
Name | Bottom elevation | Top elevation | Reference
HiRing3 | +14.048 | +14.253 | 150R-1
3 x HiRing3 | +14.047 | +14.253 | 150R-1
HiRing3 | +13.762 | +13.968 | 150R-1
HiRing3 | +13.832 | +14.038 | 150R-1
3 x HiRing3 | +13.763 | +13.968 | 150R-1
HiRing3 | +13.762 | +13.968 | 150R+S-1
HiRing3 | +9.322 | +9.527 | 150R-1
HiRing3 | +9.347 | +9.553 | 150R-1
2 x HiRing3 | +9.247 | +9.453 | 150R-1
3 x HiRing3 | +9.247 | +9.452 | 150R-1
HiRing3 | +9.547 | +9.753 | 150R+S-1
3 x HiRing3 | +4.947 | +5.152 | 150R-1

# IfcPlate: PL25*260 (2)
In: Undefined
Description: PL25*260; Material: STEEL/SN490B
Tekla Common - Bottom elevation: +9.220; Top elevation: +9.480; Phase: 1; Class: 99
Tekla Quantity - Weight: 2.9 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 24 m2; Net surface area: 0.1 m2; Height: 260 mm; Width: 25 mm; Length: 260 mm
Pset_PlateCommon - LoadBearing: no; Reference: 200R-1
BaseQuantities - Width: 260 mm; NetArea: 0.0722393 m2; GrossArea: 0.0676 m2; CrossSectionArea: 0.000625 m2; NetVolume: 0.000385652 m3; GrossVolume: 0.00129347 m3

# IfcPlate: PL25*345 (3)
In: Undefined
Description: PL25*345; Material: STEEL/SN490C
Tekla Common - Phase: 1; Class: 314
Tekla Quantity - Weight: 23.4 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 11.7 m2; Net surface area: 0.4 m2; Height: 345 mm; Width: 25 mm; Length: 345 mm
Pset_PlateCommon - LoadBearing: no
BaseQuantities - Width: 345 mm; NetArea: 0.27255 m2; GrossArea: 0.119025 m2; CrossSectionArea: 0.000625 m2; NetVolume: 0.00297563 m3; GrossVolume: 0.00297563 m3
Name | Bottom elevation | Top elevation | Preliminary mark = Reference
PLATE | -0.027 | +0.248 | K1-26
PLATE | +0.370 | +0.556 | K1-26
PLATE | +4.226 | +4.412 | K51-29

# IfcPlate: PL25*520 (8)
In: Undefined
Description: PL25*520; Material: STEEL/SN490C
Tekla Common - Preliminary mark: K1-2; Phase: 1; Class: 328
Tekla Quantity - Weight: 53.1 kg; Volume: 0 m3; Gross footprint area: 0.4 m2; Area per tons: 11.2 m2; Net surface area: 0.7 m2; Height: 520 mm; Width: 25 mm; Length: 520 mm
Pset_PlateCommon - LoadBearing: no; Reference: K1-2
BaseQuantities - Width: 520 mm; NetArea: 0.5928 m2; GrossArea: 0.2704 m2; CrossSectionArea: 0.000625 m2; NetVolume: 0.00676 m3; GrossVolume: 0.00676 m3
Name | Bottom elevation | Top elevation
2 x DIAPHRAGM | +19.062 | +19.087
2 x DIAPHRAGM | +19.483 | +19.508
2 x DIAPHRAGM | +18.847 | +18.872
2 x DIAPHRAGM | +19.268 | +19.293

# IfcPlate: PL28*144 (2)
In: Undefined
Description: PL28*144; Material: STEEL/SN490B
Tekla Common - Bottom elevation: +4.800; Top elevation: +5.445; Phase: 1; Class: 314
